** SPICE netlist generated by bigspicy.py at Fri Dec  9 10:55:48 2022 UTC
.SUBCKT iiitb_pwm_gen
+ PWM_OUT VGND VPWR clk decrease_duty increase_duty reset
** replacing ANTENNA_1 with the contents of sky130_fd_sc_hd__diode_2

** replacing FILLER_0_107 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_107_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_107_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_0_111 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_0_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_113/VPB =>[signal: VPWR w=1]]']]
FILLER_0_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_0_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_125/VPB =>[signal: VPWR w=1]]']]
FILLER_0_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_137 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_137_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_137_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_0_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_141/VPB =>[signal: VPWR w=1]]']]
FILLER_0_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_0_153 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_153/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_153/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_153/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_153/VPB =>[signal: VPWR w=1]]']]
FILLER_0_153 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_165 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_165_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_165_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_0_169 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_0_174 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_0_174/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_0_174/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_0_174/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_0_174/VPB =>[signal: VPWR w=1]]']]
FILLER_0_174 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_0_186 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_186_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_186_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_0_194 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_0_26 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_0_29 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_0_3 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_0_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_0_55 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_0_57 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_0_79 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_0_79_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_0_79_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_0_83 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_0_85 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_10_107 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_107/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_107/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_107/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_107/VPB =>[signal: VPWR w=1]]']]
FILLER_10_107 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_10_119 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_119/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_119/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_119/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_119/VPB =>[signal: VPWR w=1]]']]
FILLER_10_119 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_131 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_131_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_131_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_10_139 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_10_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_141/VPB =>[signal: VPWR w=1]]']]
FILLER_10_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_10_153 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_153/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_153/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_153/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_153/VPB =>[signal: VPWR w=1]]']]
FILLER_10_153 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_10_165 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_165/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_165/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_165/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_165/VPB =>[signal: VPWR w=1]]']]
FILLER_10_165 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_10_177 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_177/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_177/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_177/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_177/VPB =>[signal: VPWR w=1]]']]
FILLER_10_177 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_189 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_189_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_189_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_10_195 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_10_25 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_25_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_25_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_10_29 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_10_3 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_10_34 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_34_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_34_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_10_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_10_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_10_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_10_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_10_41/VPB =>[signal: VPWR w=1]]']]
FILLER_10_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_10_53 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_10_75 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_10_75_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_10_75_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_10_83 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_10_85 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_11_110 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_11_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_113/VPB =>[signal: VPWR w=1]]']]
FILLER_11_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_125/VPB =>[signal: VPWR w=1]]']]
FILLER_11_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_137/VPB =>[signal: VPWR w=1]]']]
FILLER_11_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_149 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_149/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_149/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_149/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_149/VPB =>[signal: VPWR w=1]]']]
FILLER_11_149 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_11_15 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_11_161 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_11_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_11_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_11_167 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_11_169 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_169/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_169/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_169/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_169/VPB =>[signal: VPWR w=1]]']]
FILLER_11_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_181 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_181/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_181/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_181/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_181/VPB =>[signal: VPWR w=1]]']]
FILLER_11_181 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_11_193 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_11_193_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_11_193_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_11_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_3/VPB =>[signal: VPWR w=1]]']]
FILLER_11_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_37 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_37/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_37/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_37/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_37/VPB =>[signal: VPWR w=1]]']]
FILLER_11_37 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_11_49 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_11_49_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_11_49_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_11_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_11_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_57/VPB =>[signal: VPWR w=1]]']]
FILLER_11_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_11_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_11_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_11_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_11_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_11_69/VPB =>[signal: VPWR w=1]]']]
FILLER_11_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_11_81 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_11_81_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_11_81_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_12_107 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_107/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_107/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_107/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_107/VPB =>[signal: VPWR w=1]]']]
FILLER_12_107 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_119 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_119/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_119/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_119/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_119/VPB =>[signal: VPWR w=1]]']]
FILLER_12_119 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_12_131 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_12_131_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_12_131_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_12_139 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_12_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_141/VPB =>[signal: VPWR w=1]]']]
FILLER_12_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_153 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_153/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_153/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_153/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_153/VPB =>[signal: VPWR w=1]]']]
FILLER_12_153 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_165 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_165/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_165/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_165/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_165/VPB =>[signal: VPWR w=1]]']]
FILLER_12_165 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_12_177 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_177/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_177/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_177/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_177/VPB =>[signal: VPWR w=1]]']]
FILLER_12_177 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_12_189 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_12_189_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_12_189_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_12_195 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_12_25 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_12_25_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_12_25_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_12_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_12_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_12_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_12_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_12_29/VPB =>[signal: VPWR w=1]]']]
FILLER_12_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_12_3 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_12_41 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_12_46 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_12_46_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_12_46_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_12_52 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_12_73 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_12_73_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_12_73_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_12_81 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_12_81_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_12_81_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_12_85 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_13_110 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_13_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_113/VPB =>[signal: VPWR w=1]]']]
FILLER_13_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_13_12 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_13_12_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_13_12_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_13_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_125/VPB =>[signal: VPWR w=1]]']]
FILLER_13_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_137/VPB =>[signal: VPWR w=1]]']]
FILLER_13_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_149 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_149/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_149/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_149/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_149/VPB =>[signal: VPWR w=1]]']]
FILLER_13_149 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_13_161 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_13_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_13_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_13_167 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_13_169 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_169/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_169/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_169/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_169/VPB =>[signal: VPWR w=1]]']]
FILLER_13_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_13_181 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_181/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_181/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_181/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_181/VPB =>[signal: VPWR w=1]]']]
FILLER_13_181 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_13_193 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_13_193_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_13_193_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_13_20 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_13_20_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_13_20_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_13_26 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_13_26_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_13_26_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_13_3 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_13_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_13_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_13_54 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_13_57 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_13_62 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_62/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_62/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_62/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_62/VPB =>[signal: VPWR w=1]]']]
FILLER_13_62 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_13_74 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_13_74_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_13_74_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_13_98 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_13_98/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_13_98/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_13_98/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_13_98/VPB =>[signal: VPWR w=1]]']]
FILLER_13_98 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_14_107 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_107/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_107/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_107/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_107/VPB =>[signal: VPWR w=1]]']]
FILLER_14_107 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_14_119 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_119/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_119/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_119/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_119/VPB =>[signal: VPWR w=1]]']]
FILLER_14_119 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_14_131 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_14_131_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_14_131_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_14_139 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_14_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_141/VPB =>[signal: VPWR w=1]]']]
FILLER_14_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_14_153 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_153/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_153/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_153/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_153/VPB =>[signal: VPWR w=1]]']]
FILLER_14_153 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_14_165 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_165/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_165/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_165/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_165/VPB =>[signal: VPWR w=1]]']]
FILLER_14_165 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_14_177 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_14_177/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_14_177/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_14_177/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_14_177/VPB =>[signal: VPWR w=1]]']]
FILLER_14_177 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_14_189 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_14_189_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_14_189_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_14_195 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_14_26 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_14_29 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_14_29_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_14_29_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_14_3 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_14_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_14_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_14_35 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_14_56 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_14_56_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_14_56_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_14_80 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_14_80_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_14_80_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_14_85 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_15_111 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_15_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_113/VPB =>[signal: VPWR w=1]]']]
FILLER_15_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_15_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_125/VPB =>[signal: VPWR w=1]]']]
FILLER_15_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_15_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_137/VPB =>[signal: VPWR w=1]]']]
FILLER_15_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_15_149 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_149/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_149/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_149/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_149/VPB =>[signal: VPWR w=1]]']]
FILLER_15_149 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_15_15 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_15_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_15_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_15_161 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_15_167 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_15_169 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_169/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_169/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_169/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_169/VPB =>[signal: VPWR w=1]]']]
FILLER_15_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_15_181 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_181/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_181/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_181/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_181/VPB =>[signal: VPWR w=1]]']]
FILLER_15_181 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_15_19 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_15_193 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_193_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_193_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_15_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_3/VPB =>[signal: VPWR w=1]]']]
FILLER_15_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_15_40 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_40/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_40/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_40/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_40/VPB =>[signal: VPWR w=1]]']]
FILLER_15_40 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_15_52 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_52_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_52_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_15_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_57/VPB =>[signal: VPWR w=1]]']]
FILLER_15_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_15_69 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_69_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_69_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_15_80 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_80_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_80_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_15_88 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_15_88_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_15_88_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_15_94 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_15_99 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_15_99/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_15_99/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_15_99/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_15_99/VPB =>[signal: VPWR w=1]]']]
FILLER_15_99 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_102 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_102/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_102/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_102/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_102/VPB =>[signal: VPWR w=1]]']]
FILLER_16_102 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_114 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_114/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_114/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_114/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_114/VPB =>[signal: VPWR w=1]]']]
FILLER_16_114 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_126 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_126/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_126/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_126/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_126/VPB =>[signal: VPWR w=1]]']]
FILLER_16_126 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_16_138 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_16_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_141/VPB =>[signal: VPWR w=1]]']]
FILLER_16_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_15/VPB =>[signal: VPWR w=1]]']]
FILLER_16_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_153 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_153/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_153/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_153/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_153/VPB =>[signal: VPWR w=1]]']]
FILLER_16_153 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_165 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_165/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_165/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_165/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_165/VPB =>[signal: VPWR w=1]]']]
FILLER_16_165 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_177 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_177/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_177/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_177/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_177/VPB =>[signal: VPWR w=1]]']]
FILLER_16_177 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_16_189 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_16_189_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_16_189_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_16_195 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_16_27 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_16_29 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_16_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_3/VPB =>[signal: VPWR w=1]]']]
FILLER_16_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_34 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_34/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_34/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_34/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_34/VPB =>[signal: VPWR w=1]]']]
FILLER_16_34 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_46 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_46/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_46/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_46/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_46/VPB =>[signal: VPWR w=1]]']]
FILLER_16_46 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_58 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_58/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_58/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_58/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_58/VPB =>[signal: VPWR w=1]]']]
FILLER_16_58 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_16_70 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_70/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_70/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_70/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_70/VPB =>[signal: VPWR w=1]]']]
FILLER_16_70 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_16_82 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_16_85 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_16_90 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_16_90/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_16_90/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_16_90/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_16_90/VPB =>[signal: VPWR w=1]]']]
FILLER_16_90 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_17_104 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_17_104_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_17_104_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_17_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_113/VPB =>[signal: VPWR w=1]]']]
FILLER_17_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_125/VPB =>[signal: VPWR w=1]]']]
FILLER_17_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_137/VPB =>[signal: VPWR w=1]]']]
FILLER_17_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_149 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_149/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_149/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_149/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_149/VPB =>[signal: VPWR w=1]]']]
FILLER_17_149 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_15/VPB =>[signal: VPWR w=1]]']]
FILLER_17_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_17_161 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_17_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_17_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_17_167 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_17_169 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_169/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_169/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_169/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_169/VPB =>[signal: VPWR w=1]]']]
FILLER_17_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_181 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_181/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_181/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_181/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_181/VPB =>[signal: VPWR w=1]]']]
FILLER_17_181 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_17_193 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_17_193_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_17_193_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_17_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_27/VPB =>[signal: VPWR w=1]]']]
FILLER_17_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_3/VPB =>[signal: VPWR w=1]]']]
FILLER_17_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_17_39 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_17_46 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_17_46_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_17_46_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_17_50 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_17_54 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_17_57 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_17_68 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_68/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_68/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_68/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_68/VPB =>[signal: VPWR w=1]]']]
FILLER_17_68 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_80 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_80/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_80/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_80/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_80/VPB =>[signal: VPWR w=1]]']]
FILLER_17_80 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_17_92 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_17_92/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_17_92/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_17_92/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_17_92/VPB =>[signal: VPWR w=1]]']]
FILLER_17_92 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_18_109 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_109/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_109/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_109/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_109/VPB =>[signal: VPWR w=1]]']]
FILLER_18_109 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_18_121 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_121/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_121/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_121/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_121/VPB =>[signal: VPWR w=1]]']]
FILLER_18_121 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_18_133 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_18_133_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_18_133_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_18_139 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_18_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_141/VPB =>[signal: VPWR w=1]]']]
FILLER_18_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_18_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_15/VPB =>[signal: VPWR w=1]]']]
FILLER_18_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_18_153 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_153/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_153/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_153/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_153/VPB =>[signal: VPWR w=1]]']]
FILLER_18_153 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_18_165 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_165/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_165/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_165/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_165/VPB =>[signal: VPWR w=1]]']]
FILLER_18_165 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_18_177 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_177/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_177/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_177/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_177/VPB =>[signal: VPWR w=1]]']]
FILLER_18_177 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_18_189 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_18_189_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_18_189_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_18_195 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_18_27 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_18_29 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_18_29_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_18_29_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_18_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_3/VPB =>[signal: VPWR w=1]]']]
FILLER_18_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_18_42 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_18_42_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_18_42_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_18_48 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_18_56 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_56/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_56/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_56/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_56/VPB =>[signal: VPWR w=1]]']]
FILLER_18_56 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_18_68 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_68/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_68/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_68/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_68/VPB =>[signal: VPWR w=1]]']]
FILLER_18_68 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_18_80 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_18_80_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_18_80_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_18_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_85/VPB =>[signal: VPWR w=1]]']]
FILLER_18_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_18_97 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_18_97/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_18_97/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_18_97/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_18_97/VPB =>[signal: VPWR w=1]]']]
FILLER_18_97 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_19_108 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_19_108_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_19_108_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_19_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_113/VPB =>[signal: VPWR w=1]]']]
FILLER_19_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_19_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_125/VPB =>[signal: VPWR w=1]]']]
FILLER_19_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_19_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_137/VPB =>[signal: VPWR w=1]]']]
FILLER_19_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_19_149 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_149/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_149/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_149/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_149/VPB =>[signal: VPWR w=1]]']]
FILLER_19_149 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_19_161 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_19_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_19_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_19_167 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_19_169 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_169/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_169/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_169/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_169/VPB =>[signal: VPWR w=1]]']]
FILLER_19_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_19_181 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_181/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_181/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_181/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_181/VPB =>[signal: VPWR w=1]]']]
FILLER_19_181 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_19_193 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_19_193_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_19_193_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_19_22 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_19_22_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_19_22_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_19_3 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_19_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_19_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_19_35 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_19_35_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_19_35_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_19_43 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_19_52 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_19_52_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_19_52_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_19_57 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_19_57_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_19_57_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_19_65 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_19_65_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_19_65_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_19_72 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_72/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_72/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_72/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_72/VPB =>[signal: VPWR w=1]]']]
FILLER_19_72 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_19_84 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_84/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_84/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_84/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_84/VPB =>[signal: VPWR w=1]]']]
FILLER_19_84 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_19_9 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_19_9_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_19_9_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_19_96 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_19_96/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_19_96/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_19_96/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_19_96/VPB =>[signal: VPWR w=1]]']]
FILLER_19_96 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_1_103 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_103_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_103_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_1_11 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_11_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_11_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_1_110 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_1_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_113/VPB =>[signal: VPWR w=1]]']]
FILLER_1_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_1_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_125/VPB =>[signal: VPWR w=1]]']]
FILLER_1_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_1_137 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_1_145 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_145_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_145_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_1_160 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_160_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_160_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_1_169 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_1_17 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_1_174 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_174/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_174/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_174/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_174/VPB =>[signal: VPWR w=1]]']]
FILLER_1_174 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_1_186 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_186_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_186_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_1_194 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_194_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_194_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_1_3 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_1_38 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_1_38/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_1_38/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_1_38/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_1_38/VPB =>[signal: VPWR w=1]]']]
FILLER_1_38 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_1_50 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_1_54 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_1_57 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_1_7 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_1_79 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_1_79_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_1_79_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_20_109 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_109/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_109/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_109/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_109/VPB =>[signal: VPWR w=1]]']]
FILLER_20_109 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_20_11 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_20_121 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_121/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_121/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_121/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_121/VPB =>[signal: VPWR w=1]]']]
FILLER_20_121 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_20_133 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_133_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_133_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_20_139 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_20_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_141/VPB =>[signal: VPWR w=1]]']]
FILLER_20_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_20_15 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_20_153 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_153/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_153/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_153/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_153/VPB =>[signal: VPWR w=1]]']]
FILLER_20_153 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_20_165 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_165/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_165/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_165/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_165/VPB =>[signal: VPWR w=1]]']]
FILLER_20_165 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_20_177 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_177/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_177/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_177/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_177/VPB =>[signal: VPWR w=1]]']]
FILLER_20_177 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_20_189 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_189_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_189_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_20_195 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_20_26 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_20_29 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_29_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_29_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_20_3 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_20_35 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_20_45 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_45_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_45_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_20_56 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_56/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_56/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_56/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_56/VPB =>[signal: VPWR w=1]]']]
FILLER_20_56 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_20_68 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_68_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_68_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_20_7 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_20_74 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_20_81 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_20_81_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_20_81_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_20_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_85/VPB =>[signal: VPWR w=1]]']]
FILLER_20_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_20_97 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_20_97/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_20_97/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_20_97/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_20_97/VPB =>[signal: VPWR w=1]]']]
FILLER_20_97 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_21_109 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_21_109_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_21_109_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_21_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_113/VPB =>[signal: VPWR w=1]]']]
FILLER_21_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_21_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_125/VPB =>[signal: VPWR w=1]]']]
FILLER_21_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_21_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_137/VPB =>[signal: VPWR w=1]]']]
FILLER_21_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_21_149 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_149/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_149/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_149/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_149/VPB =>[signal: VPWR w=1]]']]
FILLER_21_149 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_21_15 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_21_15_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_21_15_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_21_161 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_21_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_21_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_21_167 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_21_169 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_169/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_169/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_169/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_169/VPB =>[signal: VPWR w=1]]']]
FILLER_21_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_21_181 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_21_181_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_21_181_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_21_189 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_21_189_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_21_189_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_21_195 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_21_26 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_21_26_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_21_26_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_21_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_3/VPB =>[signal: VPWR w=1]]']]
FILLER_21_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_21_33 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_21_33_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_21_33_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_21_43 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_43/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_43/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_43/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_43/VPB =>[signal: VPWR w=1]]']]
FILLER_21_43 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_21_55 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_21_57 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_21_62 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_21_62_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_21_62_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_21_74 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_21_74_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_21_74_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_21_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_85/VPB =>[signal: VPWR w=1]]']]
FILLER_21_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_21_97 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_21_97/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_21_97/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_21_97/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_21_97/VPB =>[signal: VPWR w=1]]']]
FILLER_21_97 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_22_109 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_22_109_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_22_109_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_22_115 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_22_120 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_120/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_120/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_120/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_120/VPB =>[signal: VPWR w=1]]']]
FILLER_22_120 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_22_132 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_22_132_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_22_132_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_22_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_141/VPB =>[signal: VPWR w=1]]']]
FILLER_22_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_22_15 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_22_15_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_22_15_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_22_153 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_153/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_153/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_153/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_153/VPB =>[signal: VPWR w=1]]']]
FILLER_22_153 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_22_165 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_165/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_165/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_165/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_165/VPB =>[signal: VPWR w=1]]']]
FILLER_22_165 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_22_177 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_177/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_177/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_177/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_177/VPB =>[signal: VPWR w=1]]']]
FILLER_22_177 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_22_189 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_22_189_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_22_189_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_22_195 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_22_23 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_22_23_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_22_23_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_22_27 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_22_29 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_22_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_3/VPB =>[signal: VPWR w=1]]']]
FILLER_22_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_22_37 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_22_37_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_22_37_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_22_41 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_22_45 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_45/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_45/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_45/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_45/VPB =>[signal: VPWR w=1]]']]
FILLER_22_45 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_22_57 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_22_57_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_22_57_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_22_68 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_22_68_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_22_68_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_22_81 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_22_81_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_22_81_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_22_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_85/VPB =>[signal: VPWR w=1]]']]
FILLER_22_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_22_97 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_22_97/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_22_97/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_22_97/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_22_97/VPB =>[signal: VPWR w=1]]']]
FILLER_22_97 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_23_107 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_23_107_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_23_107_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_23_11 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_23_111 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_23_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_113/VPB =>[signal: VPWR w=1]]']]
FILLER_23_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_23_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_125/VPB =>[signal: VPWR w=1]]']]
FILLER_23_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_23_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_137/VPB =>[signal: VPWR w=1]]']]
FILLER_23_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_23_149 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_149/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_149/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_149/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_149/VPB =>[signal: VPWR w=1]]']]
FILLER_23_149 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_23_161 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_23_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_23_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_23_167 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_23_169 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_169/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_169/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_169/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_169/VPB =>[signal: VPWR w=1]]']]
FILLER_23_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_23_181 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_181/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_181/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_181/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_181/VPB =>[signal: VPWR w=1]]']]
FILLER_23_181 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_23_19 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_23_19_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_23_19_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_23_193 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_23_193_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_23_193_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_23_25 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_23_3 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_23_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_23_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_23_34 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_23_34_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_23_34_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_23_49 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_23_49_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_23_49_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_23_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_23_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_57/VPB =>[signal: VPWR w=1]]']]
FILLER_23_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_23_69 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_23_77 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_23_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_23_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_23_85 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_23_85_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_23_85_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_23_95 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_23_95/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_23_95/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_23_95/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_23_95/VPB =>[signal: VPWR w=1]]']]
FILLER_23_95 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_24_107 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_107/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_107/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_107/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_107/VPB =>[signal: VPWR w=1]]']]
FILLER_24_107 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_24_119 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_119/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_119/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_119/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_119/VPB =>[signal: VPWR w=1]]']]
FILLER_24_119 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_24_131 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_131_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_131_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_24_139 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_24_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_141/VPB =>[signal: VPWR w=1]]']]
FILLER_24_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_24_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_15/VPB =>[signal: VPWR w=1]]']]
FILLER_24_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_24_153 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_153/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_153/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_153/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_153/VPB =>[signal: VPWR w=1]]']]
FILLER_24_153 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_24_165 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_165/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_165/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_165/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_165/VPB =>[signal: VPWR w=1]]']]
FILLER_24_165 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_24_177 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_177/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_177/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_177/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_177/VPB =>[signal: VPWR w=1]]']]
FILLER_24_177 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_24_189 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_189_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_189_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_24_195 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_24_27 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_24_29 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_29_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_29_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_24_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_3/VPB =>[signal: VPWR w=1]]']]
FILLER_24_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_24_36 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_36_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_36_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_24_42 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_24_50 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_50/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_50/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_50/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_50/VPB =>[signal: VPWR w=1]]']]
FILLER_24_50 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_24_62 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_62_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_62_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_24_70 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_70/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_70/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_70/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_70/VPB =>[signal: VPWR w=1]]']]
FILLER_24_70 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_24_82 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_24_85 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_24_85_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_24_85_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_24_95 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_24_95/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_24_95/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_24_95/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_24_95/VPB =>[signal: VPWR w=1]]']]
FILLER_24_95 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_25_100 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_100/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_100/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_100/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_100/VPB =>[signal: VPWR w=1]]']]
FILLER_25_100 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_25_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_113/VPB =>[signal: VPWR w=1]]']]
FILLER_25_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_25_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_125/VPB =>[signal: VPWR w=1]]']]
FILLER_25_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_25_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_137/VPB =>[signal: VPWR w=1]]']]
FILLER_25_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_25_149 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_149/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_149/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_149/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_149/VPB =>[signal: VPWR w=1]]']]
FILLER_25_149 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_25_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_15/VPB =>[signal: VPWR w=1]]']]
FILLER_25_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_25_161 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_25_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_25_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_25_167 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_25_169 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_169/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_169/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_169/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_169/VPB =>[signal: VPWR w=1]]']]
FILLER_25_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_25_181 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_181/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_181/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_181/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_181/VPB =>[signal: VPWR w=1]]']]
FILLER_25_181 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_25_193 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_25_193_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_25_193_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_25_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_27/VPB =>[signal: VPWR w=1]]']]
FILLER_25_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_25_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_3/VPB =>[signal: VPWR w=1]]']]
FILLER_25_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_25_39 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_25_50 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_25_50_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_25_50_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_25_57 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_25_65 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_25_65_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_25_65_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_25_76 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_76/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_76/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_76/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_76/VPB =>[signal: VPWR w=1]]']]
FILLER_25_76 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_25_88 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_25_88/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_25_88/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_25_88/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_25_88/VPB =>[signal: VPWR w=1]]']]
FILLER_25_88 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_26_109 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_109/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_109/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_109/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_109/VPB =>[signal: VPWR w=1]]']]
FILLER_26_109 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_26_121 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_121/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_121/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_121/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_121/VPB =>[signal: VPWR w=1]]']]
FILLER_26_121 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_26_133 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_26_133_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_26_133_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_26_139 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_26_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_141/VPB =>[signal: VPWR w=1]]']]
FILLER_26_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_26_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_15/VPB =>[signal: VPWR w=1]]']]
FILLER_26_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_26_153 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_153/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_153/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_153/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_153/VPB =>[signal: VPWR w=1]]']]
FILLER_26_153 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_26_165 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_165/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_165/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_165/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_165/VPB =>[signal: VPWR w=1]]']]
FILLER_26_165 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_26_177 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_177/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_177/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_177/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_177/VPB =>[signal: VPWR w=1]]']]
FILLER_26_177 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_26_189 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_26_189_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_26_189_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_26_195 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_26_27 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_26_29 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_26_29_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_26_29_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** [instance FILLER_26_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_3/VPB =>[signal: VPWR w=1]]']]
FILLER_26_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_26_41 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_26_41_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_26_41_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_26_54 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_26_54_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_26_54_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_26_64 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_26_64_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_26_64_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_26_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_26_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_26_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_26_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_26_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_85/VPB =>[signal: VPWR w=1]]']]
FILLER_26_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_26_97 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_26_97/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_26_97/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_26_97/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_26_97/VPB =>[signal: VPWR w=1]]']]
FILLER_26_97 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_27_107 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_27_107_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_27_107_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_27_111 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_27_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_27_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_27_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_27_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_27_113/VPB =>[signal: VPWR w=1]]']]
FILLER_27_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_27_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_27_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_27_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_27_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_27_125/VPB =>[signal: VPWR w=1]]']]
FILLER_27_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_27_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_27_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_27_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_27_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_27_137/VPB =>[signal: VPWR w=1]]']]
FILLER_27_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_27_149 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_27_149/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_27_149/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_27_149/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_27_149/VPB =>[signal: VPWR w=1]]']]
FILLER_27_149 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_27_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_27_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_27_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_27_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_27_15/VPB =>[signal: VPWR w=1]]']]
FILLER_27_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_27_161 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_27_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_27_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_27_167 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_27_169 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_27_169/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_27_169/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_27_169/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_27_169/VPB =>[signal: VPWR w=1]]']]
FILLER_27_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_27_181 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_27_181/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_27_181/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_27_181/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_27_181/VPB =>[signal: VPWR w=1]]']]
FILLER_27_181 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_27_193 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_27_193_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_27_193_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_27_27 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_27_27_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_27_27_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_27_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_27_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_27_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_27_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_27_3/VPB =>[signal: VPWR w=1]]']]
FILLER_27_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_27_31 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_27_35 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_27_35_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_27_35_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_27_43 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_27_52 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_27_52_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_27_52_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_27_57 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_27_63 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_27_63_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_27_63_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_27_67 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_27_74 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_27_74_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_27_74_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_27_83 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_27_83/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_27_83/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_27_83/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_27_83/VPB =>[signal: VPWR w=1]]']]
FILLER_27_83 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_27_95 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_27_95/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_27_95/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_27_95/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_27_95/VPB =>[signal: VPWR w=1]]']]
FILLER_27_95 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_28_109 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_28_109/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_28_109/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_28_109/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_28_109/VPB =>[signal: VPWR w=1]]']]
FILLER_28_109 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_28_121 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_28_121/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_28_121/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_28_121/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_28_121/VPB =>[signal: VPWR w=1]]']]
FILLER_28_121 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_28_133 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_28_133_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_28_133_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_28_139 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_28_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_28_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_28_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_28_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_28_141/VPB =>[signal: VPWR w=1]]']]
FILLER_28_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_28_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_28_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_28_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_28_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_28_15/VPB =>[signal: VPWR w=1]]']]
FILLER_28_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_28_153 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_28_153/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_28_153/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_28_153/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_28_153/VPB =>[signal: VPWR w=1]]']]
FILLER_28_153 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_28_165 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_28_165/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_28_165/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_28_165/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_28_165/VPB =>[signal: VPWR w=1]]']]
FILLER_28_165 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_28_177 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_28_177/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_28_177/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_28_177/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_28_177/VPB =>[signal: VPWR w=1]]']]
FILLER_28_177 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_28_189 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_28_189_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_28_189_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_28_195 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_28_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_28_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_28_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_28_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_28_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_28_29/VPB =>[signal: VPWR w=1]]']]
FILLER_28_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_28_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_28_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_28_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_28_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_28_3/VPB =>[signal: VPWR w=1]]']]
FILLER_28_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_28_41 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_28_41_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_28_41_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_28_47 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_28_52 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_28_52/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_28_52/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_28_52/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_28_52/VPB =>[signal: VPWR w=1]]']]
FILLER_28_52 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_28_64 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_28_64/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_28_64/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_28_64/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_28_64/VPB =>[signal: VPWR w=1]]']]
FILLER_28_64 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_28_76 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_28_76_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_28_76_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_28_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_28_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_28_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_28_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_28_85/VPB =>[signal: VPWR w=1]]']]
FILLER_28_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_28_97 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_28_97/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_28_97/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_28_97/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_28_97/VPB =>[signal: VPWR w=1]]']]
FILLER_28_97 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_29_105 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_29_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_29_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_29_111 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_29_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_29_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_29_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_29_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_29_113/VPB =>[signal: VPWR w=1]]']]
FILLER_29_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_29_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_29_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_29_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_29_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_29_125/VPB =>[signal: VPWR w=1]]']]
FILLER_29_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_29_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_29_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_29_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_29_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_29_137/VPB =>[signal: VPWR w=1]]']]
FILLER_29_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_29_149 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_29_149/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_29_149/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_29_149/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_29_149/VPB =>[signal: VPWR w=1]]']]
FILLER_29_149 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_29_161 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_29_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_29_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_29_167 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_29_169 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_29_169/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_29_169/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_29_169/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_29_169/VPB =>[signal: VPWR w=1]]']]
FILLER_29_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_29_181 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_29_181/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_29_181/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_29_181/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_29_181/VPB =>[signal: VPWR w=1]]']]
FILLER_29_181 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_29_193 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_29_193_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_29_193_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_29_21 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_29_21/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_29_21/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_29_21/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_29_21/VPB =>[signal: VPWR w=1]]']]
FILLER_29_21 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_29_3 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_29_33 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_29_33/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_29_33/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_29_33/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_29_33/VPB =>[signal: VPWR w=1]]']]
FILLER_29_33 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_29_45 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_29_45_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_29_45_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_29_53 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_29_53_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_29_53_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_29_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_29_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_29_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_29_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_29_57/VPB =>[signal: VPWR w=1]]']]
FILLER_29_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_29_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_29_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_29_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_29_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_29_69/VPB =>[signal: VPWR w=1]]']]
FILLER_29_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_29_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_29_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_29_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_29_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_29_81/VPB =>[signal: VPWR w=1]]']]
FILLER_29_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_29_9 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_29_9/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_29_9/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_29_9/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_29_9/VPB =>[signal: VPWR w=1]]']]
FILLER_29_9 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_29_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_29_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_29_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_29_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_29_93/VPB =>[signal: VPWR w=1]]']]
FILLER_29_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_110 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_110_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_110_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_2_114 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_2_121 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_121/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_121/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_121/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_121/VPB =>[signal: VPWR w=1]]']]
FILLER_2_121 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_133 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_133_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_133_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_2_139 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_2_141 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_141_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_141_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_2_147 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_147_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_147_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_2_154 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_154_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_154_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_2_161 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_161/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_161/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_161/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_161/VPB =>[signal: VPWR w=1]]']]
FILLER_2_161 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_2_173 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_2_173/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_2_173/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_2_173/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_2_173/VPB =>[signal: VPWR w=1]]']]
FILLER_2_173 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_2_185 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_185_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_185_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_2_193 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_193_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_193_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_2_26 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_2_29 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_2_3 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_2_34 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_34_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_34_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_2_58 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_58_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_58_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_2_82 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_2_85 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_2_85_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_2_85_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_2_89 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_30_109 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_30_109/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_30_109/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_30_109/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_30_109/VPB =>[signal: VPWR w=1]]']]
FILLER_30_109 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_30_121 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_30_121/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_30_121/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_30_121/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_30_121/VPB =>[signal: VPWR w=1]]']]
FILLER_30_121 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_30_133 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_30_133_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_30_133_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_30_139 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_30_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_30_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_30_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_30_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_30_141/VPB =>[signal: VPWR w=1]]']]
FILLER_30_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_30_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_30_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_30_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_30_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_30_15/VPB =>[signal: VPWR w=1]]']]
FILLER_30_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_30_153 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_30_153/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_30_153/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_30_153/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_30_153/VPB =>[signal: VPWR w=1]]']]
FILLER_30_153 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_30_165 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_30_165/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_30_165/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_30_165/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_30_165/VPB =>[signal: VPWR w=1]]']]
FILLER_30_165 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_30_177 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_30_177/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_30_177/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_30_177/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_30_177/VPB =>[signal: VPWR w=1]]']]
FILLER_30_177 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_30_189 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_30_189_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_30_189_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_30_195 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_30_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_30_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_30_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_30_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_30_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_30_29/VPB =>[signal: VPWR w=1]]']]
FILLER_30_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_30_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_30_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_30_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_30_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_30_3/VPB =>[signal: VPWR w=1]]']]
FILLER_30_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_30_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_30_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_30_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_30_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_30_41/VPB =>[signal: VPWR w=1]]']]
FILLER_30_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_30_53 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_30_53/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_30_53/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_30_53/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_30_53/VPB =>[signal: VPWR w=1]]']]
FILLER_30_53 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_30_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_30_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_30_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_30_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_30_65/VPB =>[signal: VPWR w=1]]']]
FILLER_30_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_30_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_30_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_30_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_30_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_30_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_30_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_30_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_30_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_30_85/VPB =>[signal: VPWR w=1]]']]
FILLER_30_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_30_97 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_30_97/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_30_97/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_30_97/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_30_97/VPB =>[signal: VPWR w=1]]']]
FILLER_30_97 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_31_105 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_31_105_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_31_105_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_31_111 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_31_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_31_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_31_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_31_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_31_113/VPB =>[signal: VPWR w=1]]']]
FILLER_31_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_31_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_31_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_31_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_31_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_31_125/VPB =>[signal: VPWR w=1]]']]
FILLER_31_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_31_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_31_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_31_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_31_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_31_137/VPB =>[signal: VPWR w=1]]']]
FILLER_31_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_31_149 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_31_149/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_31_149/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_31_149/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_31_149/VPB =>[signal: VPWR w=1]]']]
FILLER_31_149 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_31_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_31_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_31_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_31_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_31_15/VPB =>[signal: VPWR w=1]]']]
FILLER_31_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_31_161 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_31_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_31_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_31_167 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_31_169 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_31_169/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_31_169/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_31_169/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_31_169/VPB =>[signal: VPWR w=1]]']]
FILLER_31_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_31_181 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_31_181/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_31_181/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_31_181/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_31_181/VPB =>[signal: VPWR w=1]]']]
FILLER_31_181 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_31_193 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_31_193_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_31_193_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_31_27 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_31_27/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_31_27/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_31_27/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_31_27/VPB =>[signal: VPWR w=1]]']]
FILLER_31_27 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_31_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_31_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_31_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_31_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_31_3/VPB =>[signal: VPWR w=1]]']]
FILLER_31_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_31_39 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_31_39/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_31_39/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_31_39/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_31_39/VPB =>[signal: VPWR w=1]]']]
FILLER_31_39 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_31_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_31_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_31_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_31_55 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_31_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_31_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_31_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_31_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_31_57/VPB =>[signal: VPWR w=1]]']]
FILLER_31_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_31_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_31_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_31_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_31_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_31_69/VPB =>[signal: VPWR w=1]]']]
FILLER_31_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_31_81 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_31_81/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_31_81/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_31_81/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_31_81/VPB =>[signal: VPWR w=1]]']]
FILLER_31_81 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_31_93 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_31_93/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_31_93/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_31_93/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_31_93/VPB =>[signal: VPWR w=1]]']]
FILLER_31_93 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_32_109 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_32_109_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_32_109_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_32_113 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_32_118 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_32_118/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_32_118/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_32_118/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_32_118/VPB =>[signal: VPWR w=1]]']]
FILLER_32_118 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_32_130 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_32_130_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_32_130_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_32_138 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_32_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_32_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_32_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_32_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_32_141/VPB =>[signal: VPWR w=1]]']]
FILLER_32_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_32_15 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_32_15/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_32_15/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_32_15/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_32_15/VPB =>[signal: VPWR w=1]]']]
FILLER_32_15 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_32_153 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_32_153/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_32_153/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_32_153/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_32_153/VPB =>[signal: VPWR w=1]]']]
FILLER_32_153 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_32_165 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_32_165_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_32_165_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_32_169 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_32_169/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_32_169/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_32_169/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_32_169/VPB =>[signal: VPWR w=1]]']]
FILLER_32_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_32_181 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_32_181/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_32_181/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_32_181/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_32_181/VPB =>[signal: VPWR w=1]]']]
FILLER_32_181 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_32_193 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_32_193_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_32_193_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_32_27 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_32_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_32_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_32_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_32_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_32_29/VPB =>[signal: VPWR w=1]]']]
FILLER_32_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_32_3 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_32_3/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_32_3/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_32_3/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_32_3/VPB =>[signal: VPWR w=1]]']]
FILLER_32_3 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_32_41 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_32_41/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_32_41/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_32_41/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_32_41/VPB =>[signal: VPWR w=1]]']]
FILLER_32_41 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_32_53 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_32_53_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_32_53_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_32_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_32_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_32_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_32_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_32_57/VPB =>[signal: VPWR w=1]]']]
FILLER_32_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_32_69 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_32_69/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_32_69/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_32_69/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_32_69/VPB =>[signal: VPWR w=1]]']]
FILLER_32_69 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_32_81 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_32_81_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_32_81_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_32_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_32_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_32_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_32_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_32_85/VPB =>[signal: VPWR w=1]]']]
FILLER_32_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_32_97 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_32_97/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_32_97/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_32_97/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_32_97/VPB =>[signal: VPWR w=1]]']]
FILLER_32_97 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_3_110 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_3_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_113/VPB =>[signal: VPWR w=1]]']]
FILLER_3_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_125/VPB =>[signal: VPWR w=1]]']]
FILLER_3_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_137/VPB =>[signal: VPWR w=1]]']]
FILLER_3_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_3_149 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_3_154 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_154/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_154/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_154/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_154/VPB =>[signal: VPWR w=1]]']]
FILLER_3_154 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_3_16 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_16_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_16_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_3_166 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_3_169 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_169/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_169/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_169/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_169/VPB =>[signal: VPWR w=1]]']]
FILLER_3_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_3_181 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_3_181/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_3_181/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_3_181/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_3_181/VPB =>[signal: VPWR w=1]]']]
FILLER_3_181 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_3_193 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_193_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_193_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_3_3 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_3_40 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_40_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_40_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_3_47 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_47_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_47_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_3_54 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_3_57 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_57_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_57_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_3_65 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_3_86 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_86_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_86_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_3_9 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_3_9_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_3_9_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_4_100 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_100/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_100/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_100/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_100/VPB =>[signal: VPWR w=1]]']]
FILLER_4_100 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_4_117 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_117_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_117_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_4_123 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_4_130 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_130_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_130_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_4_138 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_4_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_141/VPB =>[signal: VPWR w=1]]']]
FILLER_4_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_4_153 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_153/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_153/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_153/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_153/VPB =>[signal: VPWR w=1]]']]
FILLER_4_153 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_4_165 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_165/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_165/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_165/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_165/VPB =>[signal: VPWR w=1]]']]
FILLER_4_165 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_4_177 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_4_177/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_4_177/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_4_177/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_4_177/VPB =>[signal: VPWR w=1]]']]
FILLER_4_177 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_4_189 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_189_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_189_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_4_195 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_4_26 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_4_29 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_4_3 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_4_34 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_34_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_34_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_4_60 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_60_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_60_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_4_64 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_4_68 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_68_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_68_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_4_75 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_75_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_75_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_4_82 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_4_85 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_85_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_85_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_4_89 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_4_93 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_4_93_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_4_93_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_5_110 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_5_113 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_5_113_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_5_113_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_5_125 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_5_125_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_5_125_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_5_135 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_135/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_135/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_135/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_135/VPB =>[signal: VPWR w=1]]']]
FILLER_5_135 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_147 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_147/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_147/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_147/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_147/VPB =>[signal: VPWR w=1]]']]
FILLER_5_147 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_5_159 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_5_159_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_5_159_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_5_167 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_5_169 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_169/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_169/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_169/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_169/VPB =>[signal: VPWR w=1]]']]
FILLER_5_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_181 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_181/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_181/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_181/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_181/VPB =>[signal: VPWR w=1]]']]
FILLER_5_181 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_5_193 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_5_193_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_5_193_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_5_25 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_5_25_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_5_25_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_5_3 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_5_33 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_5_54 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_5_57 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_5_57_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_5_57_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_5_65 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_5_86 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_86/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_86/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_86/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_86/VPB =>[signal: VPWR w=1]]']]
FILLER_5_86 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_5_98 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_5_98/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_5_98/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_5_98/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_5_98/VPB =>[signal: VPWR w=1]]']]
FILLER_5_98 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_108 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_108/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_108/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_108/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_108/VPB =>[signal: VPWR w=1]]']]
FILLER_6_108 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_120 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_120/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_120/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_120/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_120/VPB =>[signal: VPWR w=1]]']]
FILLER_6_120 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_6_132 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_132_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_132_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** [instance FILLER_6_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_141/VPB =>[signal: VPWR w=1]]']]
FILLER_6_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_153 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_153/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_153/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_153/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_153/VPB =>[signal: VPWR w=1]]']]
FILLER_6_153 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_165 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_165/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_165/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_165/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_165/VPB =>[signal: VPWR w=1]]']]
FILLER_6_165 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_6_177 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_6_177/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_6_177/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_6_177/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_6_177/VPB =>[signal: VPWR w=1]]']]
FILLER_6_177 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_6_189 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_189_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_189_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_6_195 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_6_25 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_25_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_25_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_6_29 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_6_3 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_6_34 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_34_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_34_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_6_42 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_6_64 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_64_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_64_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_6_73 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_73_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_73_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_6_81 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_81_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_81_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_6_85 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_6_85_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_6_85_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_7_107 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_107_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_107_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_7_111 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_7_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_113/VPB =>[signal: VPWR w=1]]']]
FILLER_7_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_125/VPB =>[signal: VPWR w=1]]']]
FILLER_7_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_137 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_137/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_137/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_137/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_137/VPB =>[signal: VPWR w=1]]']]
FILLER_7_137 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_149 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_149/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_149/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_149/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_149/VPB =>[signal: VPWR w=1]]']]
FILLER_7_149 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_7_161 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_161_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_161_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_7_167 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_7_169 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_169/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_169/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_169/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_169/VPB =>[signal: VPWR w=1]]']]
FILLER_7_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_7_181 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_7_181/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_7_181/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_7_181/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_7_181/VPB =>[signal: VPWR w=1]]']]
FILLER_7_181 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_7_193 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_193_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_193_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_7_26 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_26_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_26_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_7_3 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_7_30 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_7_51 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_7_55 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_7_57 with the contents of sky130_fd_sc_hd__fill_2

** replacing FILLER_7_79 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_7_79_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_7_79_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_7_85 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_8_109 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_109/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_109/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_109/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_109/VPB =>[signal: VPWR w=1]]']]
FILLER_8_109 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_121 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_121_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_121_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_8_129 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_129_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_129_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_8_138 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_8_141 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_141/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_141/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_141/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_141/VPB =>[signal: VPWR w=1]]']]
FILLER_8_141 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_153 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_153/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_153/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_153/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_153/VPB =>[signal: VPWR w=1]]']]
FILLER_8_153 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_165 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_165/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_165/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_165/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_165/VPB =>[signal: VPWR w=1]]']]
FILLER_8_165 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_177 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_177/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_177/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_177/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_177/VPB =>[signal: VPWR w=1]]']]
FILLER_8_177 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_189 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_189_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_189_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_8_195 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_8_26 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_8_29 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_29/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_29/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_29/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_29/VPB =>[signal: VPWR w=1]]']]
FILLER_8_29 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_3 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_8_41 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_41_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_41_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** [instance FILLER_8_65 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_65/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_65/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_65/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_65/VPB =>[signal: VPWR w=1]]']]
FILLER_8_65 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_8_77 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_8_77_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_8_77_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** replacing FILLER_8_83 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_8_85 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_85/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_85/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_85/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_85/VPB =>[signal: VPWR w=1]]']]
FILLER_8_85 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_8_97 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_8_97/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_8_97/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_8_97/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_8_97/VPB =>[signal: VPWR w=1]]']]
FILLER_8_97 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_9_102 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_102_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_102_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_9_110 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_9_113 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_113/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_113/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_113/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_113/VPB =>[signal: VPWR w=1]]']]
FILLER_9_113 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_9_125 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_125/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_125/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_125/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_125/VPB =>[signal: VPWR w=1]]']]
FILLER_9_125 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_9_137 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_137_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_137_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** [instance FILLER_9_146 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_146/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_146/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_146/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_146/VPB =>[signal: VPWR w=1]]']]
FILLER_9_146 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_9_15 with the contents of sky130_fd_sc_hd__fill_1

** replacing FILLER_9_158 with the contents of sky130_fd_sc_hd__decap_8
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '2.89e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_158_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=2.89e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '2.89e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_158_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=2.89e+06u

** replacing FILLER_9_166 with the contents of sky130_fd_sc_hd__fill_2

** [instance FILLER_9_169 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_169/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_169/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_169/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_169/VPB =>[signal: VPWR w=1]]']]
FILLER_9_169 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_9_181 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_181/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_181/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_181/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_181/VPB =>[signal: VPWR w=1]]']]
FILLER_9_181 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_9_193 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_193_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_193_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_9_3 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing FILLER_9_36 with the contents of sky130_fd_sc_hd__decap_4
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.05e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_36_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.05e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.05e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_36_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.05e+06u

** replacing FILLER_9_40 with the contents of sky130_fd_sc_hd__fill_1

** [instance FILLER_9_44 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_44/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_44/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_44/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_44/VPB =>[signal: VPWR w=1]]']]
FILLER_9_44 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** [instance FILLER_9_57 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_57/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_57/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_57/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_57/VPB =>[signal: VPWR w=1]]']]
FILLER_9_57 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing FILLER_9_9 with the contents of sky130_fd_sc_hd__decap_6
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '1.97e+06u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_FILLER_9_9_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=1.97e+06u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '1.97e+06u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_FILLER_9_9_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=1.97e+06u

** [instance FILLER_9_90 of sky130_ef_sc_hd__decap_12, params={} connections=['VGND: [connection FILLER_9_90/VGND =>[signal: VGND w=1]]', 'VPWR: [connection FILLER_9_90/VPWR =>[signal: VPWR w=1]]', 'VNB: [connection FILLER_9_90/VNB =>[signal: VGND w=1]]', 'VPB: [connection FILLER_9_90/VPB =>[signal: VPWR w=1]]']]
FILLER_9_90 VGND VPWR VGND VPWR sky130_ef_sc_hd__decap_12
** replacing PHY_0 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_0_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_0_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_1 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_1_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_1_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_10 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_10_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_10_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_11 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_11_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_11_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_12 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_12_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_12_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_13 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_13_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_13_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_14 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_14_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_14_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_15 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_15_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_15_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_16 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_16_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_16_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_17 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_17_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_17_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_18 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_18_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_18_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_19 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_19_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_19_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_2 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_2_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_2_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_20 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_20_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_20_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_21 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_21_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_21_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_22 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_22_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_22_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_23 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_23_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_23_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_24 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_24_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_24_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_25 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_25_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_25_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_26 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_26_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_26_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_27 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_27_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_27_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_28 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_28_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_28_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_29 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_29_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_29_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_3 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_3_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_3_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_30 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_30_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_30_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_31 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_31_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_31_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_32 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_32_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_32_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_33 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_33_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_33_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_34 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_34_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_34_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_35 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_35_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_35_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_36 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_36_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_36_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_37 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_37_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_37_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_38 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_38_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_38_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_39 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_39_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_39_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_4 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_4_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_4_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_40 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_40_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_40_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_41 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_41_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_41_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_42 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_42_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_42_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_43 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_43_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_43_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_44 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_44_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_44_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_45 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_45_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_45_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_46 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_46_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_46_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_47 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_47_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_47_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_48 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_48_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_48_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_49 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_49_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_49_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_5 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_5_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_5_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_50 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_50_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_50_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_51 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_51_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_51_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_52 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_52_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_52_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_53 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_53_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_53_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_54 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_54_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_54_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_55 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_55_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_55_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_56 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_56_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_56_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_57 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_57_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_57_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_58 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_58_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_58_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_59 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_59_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_59_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_6 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_6_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_6_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_60 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_60_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_60_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_61 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_61_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_61_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_62 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_62_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_62_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_63 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_63_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_63_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_64 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_64_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_64_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_65 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_65_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_65_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_7 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_7_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_7_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_8 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_8_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_8_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing PHY_9 with the contents of sky130_fd_sc_hd__decap_3
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '870000u', 'L': '590000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: VGND w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_PHY_9_0 VPWR VGND VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=870000u L=590000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '550000u', 'L': '590000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: VPWR w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_PHY_9_1 VGND VPWR VGND VGND sky130_fd_pr__nfet_01v8 W=550000u L=590000u

** replacing TAP_100 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_101 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_102 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_103 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_104 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_105 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_106 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_107 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_108 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_109 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_110 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_111 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_112 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_113 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_114 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_115 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_116 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_117 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_118 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_119 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_120 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_121 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_122 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_123 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_124 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_125 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_126 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_127 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_128 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_129 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_130 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_131 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_132 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_133 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_134 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_135 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_136 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_137 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_138 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_139 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_140 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_141 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_142 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_143 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_144 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_145 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_146 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_147 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_148 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_149 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_150 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_151 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_152 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_153 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_154 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_155 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_156 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_157 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_158 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_159 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_160 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_161 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_162 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_163 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_164 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_165 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_166 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_167 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_168 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_169 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_170 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_171 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_172 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_173 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_174 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_175 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_176 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_177 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_178 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_179 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_180 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_181 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_182 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_183 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_184 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_185 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_186 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_187 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_66 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_67 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_68 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_69 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_70 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_71 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_72 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_73 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_74 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_75 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_76 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_77 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_78 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_79 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_80 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_81 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_82 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_83 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_84 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_85 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_86 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_87 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_88 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_89 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_90 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_91 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_92 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_93 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_94 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_95 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_96 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_97 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_98 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing TAP_99 with the contents of sky130_fd_sc_hd__tapvpwrvgnd_1

** replacing _139_ with the contents of sky130_fd_sc_hd__or3_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_29_53# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__139__0 VPWR _139__a_29_53# _081_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_111_297# w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: a_183_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__139__1 _139__a_111_297# counter_debounce[26] _139__a_183_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_29_53# w=1]]', 'g: [connection X2/g =>[signal: C w=1]]', 's: [connection X2/s =>[signal: a_111_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__139__2 _139__a_29_53# counter_debounce[27] _139__a_111_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: a_29_53# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__139__3 VGND _139__a_29_53# _081_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_29_53# w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__139__4 _139__a_29_53# counter_debounce[27] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_29_53# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__139__5 _139__a_29_53# counter_debounce[24] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_183_297# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VPWR w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__139__6 _139__a_183_297# counter_debounce[24] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: B w=1]]', 's: [connection X7/s =>[signal: a_29_53# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__139__7 VGND counter_debounce[26] _139__a_29_53# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _140_ with the contents of sky130_fd_sc_hd__or4_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__140__0 _140__a_27_297# counter_debounce[20] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: D w=1]]', 's: [connection X1/s =>[signal: a_27_297# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__140__1 VGND counter_debounce[25] _140__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_297# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__140__2 VGND counter_debounce[23] _140__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: a_27_297# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__140__3 VGND _140__a_27_297# _082_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_109_297# w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: a_205_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__140__4 _140__a_109_297# counter_debounce[22] _140__a_205_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_205_297# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_277_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__140__5 _140__a_205_297# counter_debounce[23] _140__a_277_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_27_297# w=1]]', 'g: [connection X6/g =>[signal: C w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__140__6 _140__a_27_297# counter_debounce[22] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_277_297# w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__140__7 _140__a_277_297# counter_debounce[20] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_27_297# w=1]]', 'g: [connection X8/g =>[signal: D w=1]]', 's: [connection X8/s =>[signal: a_109_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__140__8 _140__a_27_297# counter_debounce[25] _140__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: a_27_297# w=1]]', 's: [connection X9/s =>[signal: X w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__140__9 VPWR _140__a_27_297# _082_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _141_ with the contents of sky130_fd_sc_hd__or4_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__141__0 _141__a_27_297# counter_debounce[16] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: D w=1]]', 's: [connection X1/s =>[signal: a_27_297# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__141__1 VGND counter_debounce[21] _141__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_297# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__141__2 VGND counter_debounce[19] _141__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: a_27_297# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__141__3 VGND _141__a_27_297# _083_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_109_297# w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: a_205_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__141__4 _141__a_109_297# counter_debounce[18] _141__a_205_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_205_297# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_277_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__141__5 _141__a_205_297# counter_debounce[19] _141__a_277_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_27_297# w=1]]', 'g: [connection X6/g =>[signal: C w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__141__6 _141__a_27_297# counter_debounce[18] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_277_297# w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__141__7 _141__a_277_297# counter_debounce[16] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_27_297# w=1]]', 'g: [connection X8/g =>[signal: D w=1]]', 's: [connection X8/s =>[signal: a_109_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__141__8 _141__a_27_297# counter_debounce[21] _141__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: a_27_297# w=1]]', 's: [connection X9/s =>[signal: X w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__141__9 VPWR _141__a_27_297# _083_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _142_ with the contents of sky130_fd_sc_hd__or3_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_30_53# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__142__0 VPWR _142__a_30_53# _084_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_112_297# w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: a_184_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__142__1 _142__a_112_297# _082_ _142__a_184_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_184_297# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__142__2 _142__a_184_297# _081_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_30_53# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__142__3 _084_ _142__a_30_53# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_30_53# w=1]]', 'g: [connection X4/g =>[signal: A w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__142__4 _142__a_30_53# _081_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_30_53# w=1]]', 'g: [connection X5/g =>[signal: C w=1]]', 's: [connection X5/s =>[signal: a_112_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__142__5 _142__a_30_53# _083_ _142__a_112_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_30_53# w=1]]', 'g: [connection X6/g =>[signal: C w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__142__6 _142__a_30_53# _083_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_30_53# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__142__7 _084_ _142__a_30_53# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: B w=1]]', 's: [connection X8/s =>[signal: a_30_53# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__142__8 VGND _082_ _142__a_30_53# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: a_30_53# w=1]]', 's: [connection X9/s =>[signal: X w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__142__9 VGND _142__a_30_53# _084_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _143_ with the contents of sky130_fd_sc_hd__or4_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__143__0 _143__a_27_297# counter_debounce[4] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: D w=1]]', 's: [connection X1/s =>[signal: a_27_297# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__143__1 VGND counter_debounce[8] _143__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_297# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__143__2 VGND counter_debounce[7] _143__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: a_27_297# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__143__3 VGND _143__a_27_297# _085_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_109_297# w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: a_205_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__143__4 _143__a_109_297# counter_debounce[6] _143__a_205_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_205_297# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_277_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__143__5 _143__a_205_297# counter_debounce[7] _143__a_277_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_27_297# w=1]]', 'g: [connection X6/g =>[signal: C w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__143__6 _143__a_27_297# counter_debounce[6] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_277_297# w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__143__7 _143__a_277_297# counter_debounce[4] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_27_297# w=1]]', 'g: [connection X8/g =>[signal: D w=1]]', 's: [connection X8/s =>[signal: a_109_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__143__8 _143__a_27_297# counter_debounce[8] _143__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: a_27_297# w=1]]', 's: [connection X9/s =>[signal: X w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__143__9 VPWR _143__a_27_297# _085_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _144_ with the contents of sky130_fd_sc_hd__or4_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__144__0 _144__a_27_297# counter_debounce[1] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: D w=1]]', 's: [connection X1/s =>[signal: a_27_297# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__144__1 VGND counter_debounce[5] _144__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_297# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__144__2 VGND counter_debounce[3] _144__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: a_27_297# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__144__3 VGND _144__a_27_297# _086_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_109_297# w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: a_205_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__144__4 _144__a_109_297# counter_debounce[2] _144__a_205_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_205_297# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_277_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__144__5 _144__a_205_297# counter_debounce[3] _144__a_277_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_27_297# w=1]]', 'g: [connection X6/g =>[signal: C w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__144__6 _144__a_27_297# counter_debounce[2] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_277_297# w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__144__7 _144__a_277_297# counter_debounce[1] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_27_297# w=1]]', 'g: [connection X8/g =>[signal: D w=1]]', 's: [connection X8/s =>[signal: a_109_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__144__8 _144__a_27_297# counter_debounce[5] _144__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: a_27_297# w=1]]', 's: [connection X9/s =>[signal: X w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__144__9 VPWR _144__a_27_297# _086_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _145_ with the contents of sky130_fd_sc_hd__or4_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__145__0 _145__a_27_297# counter_debounce[9] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: D w=1]]', 's: [connection X1/s =>[signal: a_27_297# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__145__1 VGND counter_debounce[13] _145__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_297# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__145__2 VGND counter_debounce[11] _145__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: a_27_297# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__145__3 VGND _145__a_27_297# _087_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_109_297# w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: a_205_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__145__4 _145__a_109_297# counter_debounce[10] _145__a_205_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_205_297# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_277_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__145__5 _145__a_205_297# counter_debounce[11] _145__a_277_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_27_297# w=1]]', 'g: [connection X6/g =>[signal: C w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__145__6 _145__a_27_297# counter_debounce[10] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_277_297# w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__145__7 _145__a_277_297# counter_debounce[9] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_27_297# w=1]]', 'g: [connection X8/g =>[signal: D w=1]]', 's: [connection X8/s =>[signal: a_109_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__145__8 _145__a_27_297# counter_debounce[13] _145__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: a_27_297# w=1]]', 's: [connection X9/s =>[signal: X w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__145__9 VPWR _145__a_27_297# _087_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _146_ with the contents of sky130_fd_sc_hd__or4_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__146__0 _146__a_27_297# counter_debounce[12] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: D w=1]]', 's: [connection X1/s =>[signal: a_27_297# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__146__1 VGND counter_debounce[17] _146__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_297# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__146__2 VGND counter_debounce[15] _146__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: a_27_297# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__146__3 VGND _146__a_27_297# _088_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_109_297# w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: a_205_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__146__4 _146__a_109_297# counter_debounce[14] _146__a_205_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_205_297# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_277_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__146__5 _146__a_205_297# counter_debounce[15] _146__a_277_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_27_297# w=1]]', 'g: [connection X6/g =>[signal: C w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__146__6 _146__a_27_297# counter_debounce[14] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_277_297# w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__146__7 _146__a_277_297# counter_debounce[12] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_27_297# w=1]]', 'g: [connection X8/g =>[signal: D w=1]]', 's: [connection X8/s =>[signal: a_109_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__146__8 _146__a_27_297# counter_debounce[17] _146__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: a_27_297# w=1]]', 's: [connection X9/s =>[signal: X w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__146__9 VPWR _146__a_27_297# _088_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _147_ with the contents of sky130_fd_sc_hd__or4_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__147__0 _147__a_27_297# _085_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: D w=1]]', 's: [connection X1/s =>[signal: a_27_297# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__147__1 VGND _088_ _147__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_27_297# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__147__2 _089_ _147__a_27_297# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: a_27_297# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__147__3 VGND _086_ _147__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: a_27_297# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__147__4 VGND _147__a_27_297# _089_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_109_297# w=1]]', 'g: [connection X5/g =>[signal: C w=1]]', 's: [connection X5/s =>[signal: a_205_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__147__5 _147__a_109_297# _087_ _147__a_205_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_205_297# w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: a_277_297# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__147__6 _147__a_205_297# _086_ _147__a_277_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_27_297# w=1]]', 'g: [connection X7/g =>[signal: C w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__147__7 _147__a_27_297# _087_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_277_297# w=1]]', 'g: [connection X8/g =>[signal: A w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__147__8 _147__a_277_297# _085_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: X w=1]]', 'g: [connection X9/g =>[signal: a_27_297# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__147__9 _089_ _147__a_27_297# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_27_297# w=1]]', 'g: [connection X10/g =>[signal: D w=1]]', 's: [connection X10/s =>[signal: a_109_297# w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__147__10 _147__a_27_297# _088_ _147__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_27_297# w=1]]', 's: [connection X11/s =>[signal: X w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__147__11 VPWR _147__a_27_297# _089_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _148_ with the contents of sky130_fd_sc_hd__or3_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_29_53# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__148__0 VPWR _148__a_29_53# _090_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_111_297# w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: a_183_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__148__1 _148__a_111_297# _084_ _148__a_183_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_29_53# w=1]]', 'g: [connection X2/g =>[signal: C w=1]]', 's: [connection X2/s =>[signal: a_111_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__148__2 _148__a_29_53# _089_ _148__a_111_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: a_29_53# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__148__3 VGND _148__a_29_53# _090_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_29_53# w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__148__4 _148__a_29_53# _089_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_29_53# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__148__5 _148__a_29_53# _080_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_183_297# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VPWR w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__148__6 _148__a_183_297# _080_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: B w=1]]', 's: [connection X7/s =>[signal: a_29_53# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__148__7 VGND _084_ _148__a_29_53# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _149_ with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__149__0 _091_ _149__a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__149__1 _149__a_27_47# _090_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__149__2 VGND _149__a_27_47# _091_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__149__3 _091_ _149__a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__149__4 VPWR _149__a_27_47# _091_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__149__5 _149__a_27_47# _090_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _150_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__150__0 VPWR _091_ _150__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__150__1 _150__a_76_199# tmp3 _150__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__150__2 _150__a_535_374# _150__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__150__3 VPWR _091_ _150__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__150__4 _150__a_76_199# tmp4 _150__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__150__5 _150__a_218_47# tmp4 _150__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__150__6 _150__a_218_374# tmp3 _150__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__150__7 _092_ _150__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__150__8 _092_ _150__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__150__9 VGND _091_ _150__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__150__10 VGND _091_ _150__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__150__11 _150__a_439_47# _150__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _151_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__151__0 VGND _092_ _151__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__151__1 _079_ _151__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__151__2 _079_ _151__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__151__3 VPWR _092_ _151__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _152_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__152__0 VPWR _091_ _152__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__152__1 _152__a_76_199# net1 _152__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__152__2 _152__a_535_374# _152__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__152__3 VPWR _091_ _152__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__152__4 _152__a_76_199# tmp3 _152__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__152__5 _152__a_218_47# tmp3 _152__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__152__6 _152__a_218_374# net1 _152__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__152__7 _093_ _152__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__152__8 _093_ _152__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__152__9 VGND _091_ _152__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__152__10 VGND _091_ _152__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__152__11 _152__a_439_47# _152__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _153_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__153__0 VGND _093_ _153__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__153__1 _078_ _153__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__153__2 _078_ _153__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__153__3 VPWR _093_ _153__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _154_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__154__0 VPWR _091_ _154__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__154__1 _154__a_76_199# tmp1 _154__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__154__2 _154__a_535_374# _154__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__154__3 VPWR _091_ _154__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__154__4 _154__a_76_199# tmp2 _154__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__154__5 _154__a_218_47# tmp2 _154__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__154__6 _154__a_218_374# tmp1 _154__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__154__7 _094_ _154__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__154__8 _094_ _154__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__154__9 VGND _091_ _154__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__154__10 VGND _091_ _154__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__154__11 _154__a_439_47# _154__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _155_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__155__0 VGND _094_ _155__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__155__1 _077_ _155__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__155__2 _077_ _155__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__155__3 VPWR _094_ _155__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _156_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__156__0 VPWR _091_ _156__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__156__1 _156__a_76_199# net2 _156__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__156__2 _156__a_535_374# _156__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__156__3 VPWR _091_ _156__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__156__4 _156__a_76_199# tmp1 _156__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__156__5 _156__a_218_47# tmp1 _156__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__156__6 _156__a_218_374# net2 _156__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__156__7 _095_ _156__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__156__8 _095_ _156__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__156__9 VGND _091_ _156__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__156__10 VGND _091_ _156__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__156__11 _156__a_439_47# _156__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _157_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__157__0 VGND _095_ _157__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__157__1 _076_ _157__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__157__2 _076_ _157__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__157__3 VPWR _095_ _157__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _159_ with the contents of sky130_fd_sc_hd__o21a_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_382_297# w=1]]', 'g: [connection X0/g =>[signal: A1 w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__159__0 _159__a_382_297# DUTY_CYCLE[2] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: a_297_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__159__1 VGND DUTY_CYCLE[2] _159__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_79_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_297_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__159__2 _159__a_79_21# DUTY_CYCLE[3] _159__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_79_21# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__159__3 _097_ _159__a_79_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_297_47# w=1]]', 'g: [connection X4/g =>[signal: A2 w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__159__4 _159__a_297_47# DUTY_CYCLE[1] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_79_21# w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_382_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__159__5 _159__a_79_21# DUTY_CYCLE[1] _159__a_382_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_79_21# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__159__6 VPWR DUTY_CYCLE[3] _159__a_79_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_79_21# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__159__7 _097_ _159__a_79_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _160_ with the contents of sky130_fd_sc_hd__or4_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__160__0 _160__a_27_297# tmp2 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: D w=1]]', 's: [connection X1/s =>[signal: a_27_297# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__160__1 VGND _097_ _160__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_27_297# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__160__2 _098_ _160__a_27_297# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: a_27_297# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__160__3 VGND _096_ _160__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: a_27_297# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__160__4 VGND _160__a_27_297# _098_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_109_297# w=1]]', 'g: [connection X5/g =>[signal: C w=1]]', 's: [connection X5/s =>[signal: a_205_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__160__5 _160__a_109_297# _091_ _160__a_205_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_205_297# w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: a_277_297# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__160__6 _160__a_205_297# _096_ _160__a_277_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_27_297# w=1]]', 'g: [connection X7/g =>[signal: C w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__160__7 _160__a_27_297# _091_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_277_297# w=1]]', 'g: [connection X8/g =>[signal: A w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__160__8 _160__a_277_297# tmp2 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: X w=1]]', 'g: [connection X9/g =>[signal: a_27_297# w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__160__9 _098_ _160__a_27_297# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_27_297# w=1]]', 'g: [connection X10/g =>[signal: D w=1]]', 's: [connection X10/s =>[signal: a_109_297# w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__160__10 _160__a_27_297# _097_ _160__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X11 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VPWR w=1]]', 'g: [connection X11/g =>[signal: a_27_297# w=1]]', 's: [connection X11/s =>[signal: X w=1]]', 'b: [connection X11/b =>[signal: VPB w=1]]']]
X__160__11 VPWR _160__a_27_297# _098_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _161_ with the contents of sky130_fd_sc_hd__xnor2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_377_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__161__0 VPWR DUTY_CYCLE[3] _161__a_377_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_377_297# w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__161__1 _161__a_377_297# _098_ _099_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: a_47_47# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__161__2 _099_ _161__a_47_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_129_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__161__3 _161__a_129_47# DUTY_CYCLE[3] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_285_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__161__4 VGND _098_ _161__a_285_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_47_47# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_129_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__161__5 _161__a_47_47# _098_ _161__a_129_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: a_47_47# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__161__6 VPWR _098_ _161__a_47_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_47_47# w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__161__7 _161__a_47_47# DUTY_CYCLE[3] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: A w=1]]', 's: [connection X8/s =>[signal: a_285_47# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__161__8 VGND DUTY_CYCLE[3] _161__a_285_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_285_47# w=1]]', 'g: [connection X9/g =>[signal: a_47_47# w=1]]', 's: [connection X9/s =>[signal: Y w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__161__9 _161__a_285_47# _161__a_47_47# _099_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _162_ with the contents of sky130_fd_sc_hd__dlymetal6s2s_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_381_47# w=1]]', 'g: [connection X0/g =>[signal: X w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__162__0 _162__a_381_47# _100_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_381_47# w=1]]', 'g: [connection X1/g =>[signal: X w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__162__1 _162__a_381_47# _100_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_664_47# w=1]]', 'g: [connection X2/g =>[signal: a_558_47# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__162__2 _162__a_664_47# _162__a_558_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_62_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__162__3 _162__a_62_47# DUTY_CYCLE[0] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_664_47# w=1]]', 's: [connection X4/s =>[signal: a_841_47# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__162__4 VPWR _162__a_664_47# _162__a_841_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_381_47# w=1]]', 's: [connection X5/s =>[signal: a_558_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__162__5 VGND _162__a_381_47# _162__a_558_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: a_62_47# w=1]]', 's: [connection X6/s =>[signal: X w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__162__6 VGND _162__a_62_47# _100_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: a_62_47# w=1]]', 's: [connection X7/s =>[signal: X w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__162__7 VPWR _162__a_62_47# _100_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_664_47# w=1]]', 'g: [connection X8/g =>[signal: a_558_47# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__162__8 _162__a_664_47# _162__a_558_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_62_47# w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: VPWR w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__162__9 _162__a_62_47# DUTY_CYCLE[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VPWR w=1]]', 'g: [connection X10/g =>[signal: a_381_47# w=1]]', 's: [connection X10/s =>[signal: a_558_47# w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__162__10 VPWR _162__a_381_47# _162__a_558_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: VGND w=1]]', 'g: [connection X11/g =>[signal: a_664_47# w=1]]', 's: [connection X11/s =>[signal: a_841_47# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__162__11 VGND _162__a_664_47# _162__a_841_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _163_ with the contents of sky130_fd_sc_hd__or2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_150_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__163__0 _163__a_150_297# tmp2 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: a_68_297# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__163__1 VGND _163__a_68_297# _101_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_68_297# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__163__2 VGND _097_ _163__a_68_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_68_297# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__163__3 _163__a_68_297# tmp2 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_68_297# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_150_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__163__4 _163__a_68_297# _097_ _163__a_150_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_68_297# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__163__5 VPWR _163__a_68_297# _101_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _164_ with the contents of sky130_fd_sc_hd__or4_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__164__0 _164__a_27_297# _096_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: D w=1]]', 's: [connection X1/s =>[signal: a_27_297# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__164__1 VGND _101_ _164__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: a_27_297# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__164__2 VGND DUTY_CYCLE[1] _164__a_27_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: a_27_297# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__164__3 VGND _164__a_27_297# _102_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_109_297# w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: a_205_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__164__4 _164__a_109_297# _091_ _164__a_205_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_205_297# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_277_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__164__5 _164__a_205_297# DUTY_CYCLE[1] _164__a_277_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_27_297# w=1]]', 'g: [connection X6/g =>[signal: C w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__164__6 _164__a_27_297# _091_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_277_297# w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__164__7 _164__a_277_297# _096_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_27_297# w=1]]', 'g: [connection X8/g =>[signal: D w=1]]', 's: [connection X8/s =>[signal: a_109_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__164__8 _164__a_27_297# _101_ _164__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: a_27_297# w=1]]', 's: [connection X9/s =>[signal: X w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__164__9 VPWR _164__a_27_297# _102_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _165_ with the contents of sky130_fd_sc_hd__o31a_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_253_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__165__0 _165__a_253_47# _091_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: a_253_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__165__1 VPWR _096_ _165__a_253_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_103_199# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__165__2 _103_ _165__a_103_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_103_199# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__165__3 _103_ _165__a_103_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_253_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__165__4 VGND _096_ _165__a_253_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_103_199# w=1]]', 'g: [connection X5/g =>[signal: B1 w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__165__5 _165__a_103_199# DUTY_CYCLE[1] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_253_47# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_103_199# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__165__6 _165__a_253_47# DUTY_CYCLE[1] _165__a_103_199# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: A3 w=1]]', 's: [connection X7/s =>[signal: a_253_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__165__7 VGND _101_ _165__a_253_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_253_297# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: a_337_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__165__8 _165__a_253_297# _091_ _165__a_337_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_337_297# w=1]]', 'g: [connection X9/g =>[signal: A3 w=1]]', 's: [connection X9/s =>[signal: a_103_199# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__165__9 _165__a_337_297# _101_ _165__a_103_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _166_ with the contents of sky130_fd_sc_hd__a21o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_384_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__166__0 _166__a_384_47# _102_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_81_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__166__1 _104_ _166__a_81_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_81_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_299_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__166__2 _166__a_81_21# _103_ _166__a_299_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: a_81_21# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__166__3 VGND _103_ _166__a_81_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_299_297# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__166__4 _166__a_299_297# _100_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_299_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__166__5 VPWR _102_ _166__a_299_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: X w=1]]', 'g: [connection X6/g =>[signal: a_81_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__166__6 _104_ _166__a_81_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_81_21# w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_384_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__166__7 _166__a_81_21# _100_ _166__a_384_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _168_ with the contents of sky130_fd_sc_hd__xnor2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_377_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__168__0 VPWR _105_ _168__a_377_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_377_297# w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__168__1 _168__a_377_297# _098_ _106_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: a_47_47# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__168__2 _106_ _168__a_47_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_129_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__168__3 _168__a_129_47# _105_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_285_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__168__4 VGND _098_ _168__a_285_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_47_47# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_129_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__168__5 _168__a_47_47# _098_ _168__a_129_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: a_47_47# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__168__6 VPWR _098_ _168__a_47_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_47_47# w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__168__7 _168__a_47_47# _105_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: A w=1]]', 's: [connection X8/s =>[signal: a_285_47# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__168__8 VGND _105_ _168__a_285_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_285_47# w=1]]', 'g: [connection X9/g =>[signal: a_47_47# w=1]]', 's: [connection X9/s =>[signal: Y w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__168__9 _168__a_285_47# _168__a_47_47# _106_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _173_ with the contents of sky130_fd_sc_hd__a41o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: B1 w=1]]', 's: [connection X0/s =>[signal: a_79_21# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__173__0 VGND tmp4 _173__a_79_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A4 w=1]]', 's: [connection X1/s =>[signal: a_297_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__173__1 VPWR _110_ _173__a_297_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_79_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_297_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__173__2 _173__a_79_21# tmp4 _173__a_297_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A2 w=1]]', 's: [connection X3/s =>[signal: a_297_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__173__3 VPWR _105_ _173__a_297_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_297_297# w=1]]', 'g: [connection X4/g =>[signal: A3 w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__173__4 _173__a_297_297# _109_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_297_297# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__173__5 _173__a_297_297# _108_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_465_47# w=1]]', 'g: [connection X6/g =>[signal: A3 w=1]]', 's: [connection X6/s =>[signal: a_561_47# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__173__6 _173__a_465_47# _109_ _173__a_561_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_561_47# w=1]]', 'g: [connection X7/g =>[signal: A4 w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__173__7 _173__a_561_47# _110_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_381_47# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: a_465_47# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__173__8 _173__a_381_47# _105_ _173__a_465_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: X w=1]]', 'g: [connection X9/g =>[signal: a_79_21# w=1]]', 's: [connection X9/s =>[signal: VGND w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__173__9 _111_ _173__a_79_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_79_21# w=1]]', 's: [connection X10/s =>[signal: VPWR w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__173__10 _111_ _173__a_79_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_79_21# w=1]]', 'g: [connection X11/g =>[signal: A1 w=1]]', 's: [connection X11/s =>[signal: a_381_47# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__173__11 _173__a_79_21# _108_ _173__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _174_ with the contents of sky130_fd_sc_hd__o31a_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_253_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__174__0 _174__a_253_47# _091_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: a_253_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__174__1 VPWR _107_ _174__a_253_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_103_199# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__174__2 _112_ _174__a_103_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_103_199# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__174__3 _112_ _174__a_103_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_253_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__174__4 VGND _107_ _174__a_253_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_103_199# w=1]]', 'g: [connection X5/g =>[signal: B1 w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__174__5 _174__a_103_199# _098_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_253_47# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_103_199# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__174__6 _174__a_253_47# _098_ _174__a_103_199# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: A3 w=1]]', 's: [connection X7/s =>[signal: a_253_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__174__7 VGND _111_ _174__a_253_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_253_297# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: a_337_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__174__8 _174__a_253_297# _091_ _174__a_337_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_337_297# w=1]]', 'g: [connection X9/g =>[signal: A3 w=1]]', 's: [connection X9/s =>[signal: a_103_199# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__174__9 _174__a_337_297# _111_ _174__a_103_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _175_ with the contents of sky130_fd_sc_hd__and2_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: a_59_75# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__175__0 VGND _175__a_59_75# _113_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: a_59_75# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__175__1 VPWR DUTY_CYCLE[2] _175__a_59_75# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_59_75# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: a_145_75# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__175__2 _175__a_59_75# DUTY_CYCLE[2] _175__a_145_75# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_59_75# w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__175__3 _175__a_59_75# _098_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_145_75# w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__175__4 _175__a_145_75# _098_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_59_75# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__175__5 VPWR _175__a_59_75# _113_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _176_ with the contents of sky130_fd_sc_hd__a211o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: a_300_47# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__176__0 VGND _106_ _176__a_300_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_80_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__176__1 _114_ _176__a_80_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_80_21# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__176__2 _114_ _176__a_80_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_300_47# w=1]]', 'g: [connection X3/g =>[signal: A1 w=1]]', 's: [connection X3/s =>[signal: a_80_21# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__176__3 _176__a_300_47# _104_ _176__a_80_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_80_21# w=1]]', 'g: [connection X4/g =>[signal: B1 w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__176__4 _176__a_80_21# _112_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_472_297# w=1]]', 'g: [connection X5/g =>[signal: C1 w=1]]', 's: [connection X5/s =>[signal: a_80_21# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__176__5 _176__a_472_297# _113_ _176__a_80_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: C1 w=1]]', 's: [connection X6/s =>[signal: a_80_21# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__176__6 VGND _113_ _176__a_80_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_217_297# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__176__7 VPWR _104_ _176__a_217_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_217_297# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__176__8 _176__a_217_297# _106_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_217_297# w=1]]', 'g: [connection X9/g =>[signal: B1 w=1]]', 's: [connection X9/s =>[signal: a_472_297# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__176__9 _176__a_217_297# _112_ _176__a_472_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _177_ with the contents of sky130_fd_sc_hd__xnor2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_377_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__177__0 VPWR _099_ _177__a_377_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_377_297# w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__177__1 _177__a_377_297# _114_ _075_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: a_47_47# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__177__2 _075_ _177__a_47_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_129_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__177__3 _177__a_129_47# _099_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_285_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__177__4 VGND _114_ _177__a_285_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_47_47# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_129_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__177__5 _177__a_47_47# _114_ _177__a_129_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: a_47_47# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__177__6 VPWR _114_ _177__a_47_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_47_47# w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__177__7 _177__a_47_47# _099_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: A w=1]]', 's: [connection X8/s =>[signal: a_285_47# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__177__8 VGND _099_ _177__a_285_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_285_47# w=1]]', 'g: [connection X9/g =>[signal: a_47_47# w=1]]', 's: [connection X9/s =>[signal: Y w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__177__9 _177__a_285_47# _177__a_47_47# _075_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _178_ with the contents of sky130_fd_sc_hd__xor2_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_35_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__178__0 _178__a_35_297# _104_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: a_35_297# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__178__1 VGND _106_ _178__a_35_297# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_35_297# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__178__2 _115_ _178__a_35_297# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_285_297# w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__178__3 _178__a_285_297# _106_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A w=1]]', 's: [connection X4/s =>[signal: a_285_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__178__4 VPWR _104_ _178__a_285_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_35_297# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_117_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__178__5 _178__a_35_297# _106_ _178__a_117_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_117_297# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VPWR w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__178__6 _178__a_117_297# _104_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_285_47# w=1]]', 'g: [connection X7/g =>[signal: B w=1]]', 's: [connection X7/s =>[signal: X w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__178__7 _178__a_285_47# _106_ _115_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_285_297# w=1]]', 'g: [connection X8/g =>[signal: a_35_297# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__178__8 _178__a_285_297# _178__a_35_297# _115_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_285_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__178__9 VGND _104_ _178__a_285_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _179_ with the contents of sky130_fd_sc_hd__or3_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_29_53# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__179__0 VPWR _179__a_29_53# _116_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_111_297# w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: a_183_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__179__1 _179__a_111_297# _091_ _179__a_183_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_29_53# w=1]]', 'g: [connection X2/g =>[signal: C w=1]]', 's: [connection X2/s =>[signal: a_111_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__179__2 _179__a_29_53# _101_ _179__a_111_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: a_29_53# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__179__3 VGND _179__a_29_53# _116_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_29_53# w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__179__4 _179__a_29_53# _101_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_29_53# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__179__5 _179__a_29_53# _096_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_183_297# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VPWR w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__179__6 _179__a_183_297# _096_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: B w=1]]', 's: [connection X7/s =>[signal: a_29_53# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__179__7 VGND _091_ _179__a_29_53# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _180_ with the contents of sky130_fd_sc_hd__o31a_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_253_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__180__0 _180__a_253_47# _091_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: a_253_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__180__1 VPWR _107_ _180__a_253_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_103_199# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__180__2 _117_ _180__a_103_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_103_199# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__180__3 _117_ _180__a_103_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_253_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__180__4 VGND _107_ _180__a_253_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_103_199# w=1]]', 'g: [connection X5/g =>[signal: B1 w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__180__5 _180__a_103_199# _116_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_253_47# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_103_199# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__180__6 _180__a_253_47# _116_ _180__a_103_199# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: A3 w=1]]', 's: [connection X7/s =>[signal: a_253_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__180__7 VGND _111_ _180__a_253_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_253_297# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: a_337_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__180__8 _180__a_253_297# _091_ _180__a_337_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_337_297# w=1]]', 'g: [connection X9/g =>[signal: A3 w=1]]', 's: [connection X9/s =>[signal: a_103_199# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__180__9 _180__a_337_297# _111_ _180__a_103_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _181_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__181__0 VPWR _117_ _181__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__181__1 _181__a_76_199# _115_ _181__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__181__2 _181__a_535_374# _181__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__181__3 VPWR _117_ _181__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__181__4 _181__a_76_199# DUTY_CYCLE[2] _181__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__181__5 _181__a_218_47# DUTY_CYCLE[2] _181__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__181__6 _181__a_218_374# _115_ _181__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__181__7 _118_ _181__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__181__8 _118_ _181__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__181__9 VGND _117_ _181__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__181__10 VGND _117_ _181__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__181__11 _181__a_439_47# _181__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _182_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__182__0 VGND _118_ _182__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__182__1 _074_ _182__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__182__2 _074_ _182__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__182__3 VPWR _118_ _182__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _183_ with the contents of sky130_fd_sc_hd__or2b_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_219_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__183__0 _183__a_219_297# _103_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_53# w=1]]', 'g: [connection X1/g =>[signal: B_N w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__183__1 _183__a_27_53# _102_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_53# w=1]]', 's: [connection X2/s =>[signal: a_219_297# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__183__2 VGND _183__a_27_53# _183__a_219_297# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: a_219_297# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__183__3 VGND _183__a_219_297# _119_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_219_297# w=1]]', 'g: [connection X4/g =>[signal: a_27_53# w=1]]', 's: [connection X4/s =>[signal: a_301_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__183__4 _183__a_219_297# _183__a_27_53# _183__a_301_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_301_297# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__183__5 _183__a_301_297# _103_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: B_N w=1]]', 's: [connection X6/s =>[signal: a_27_53# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__183__6 VPWR _102_ _183__a_27_53# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: a_219_297# w=1]]', 's: [connection X7/s =>[signal: X w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__183__7 VPWR _183__a_219_297# _119_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _184_ with the contents of sky130_fd_sc_hd__xnor2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_377_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__184__0 VPWR _100_ _184__a_377_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_377_297# w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__184__1 _184__a_377_297# _119_ _120_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: a_47_47# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__184__2 _120_ _184__a_47_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_129_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__184__3 _184__a_129_47# _100_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_285_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__184__4 VGND _119_ _184__a_285_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_47_47# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_129_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__184__5 _184__a_47_47# _119_ _184__a_129_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: a_47_47# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__184__6 VPWR _119_ _184__a_47_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_47_47# w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__184__7 _184__a_47_47# _100_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: A w=1]]', 's: [connection X8/s =>[signal: a_285_47# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__184__8 VGND _100_ _184__a_285_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_285_47# w=1]]', 'g: [connection X9/g =>[signal: a_47_47# w=1]]', 's: [connection X9/s =>[signal: Y w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__184__9 _184__a_285_47# _184__a_47_47# _120_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _185_ with the contents of sky130_fd_sc_hd__mux2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: S w=1]]', 's: [connection X0/s =>[signal: a_218_374# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__185__0 VPWR _117_ _185__a_218_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_76_199# w=1]]', 'g: [connection X1/g =>[signal: A0 w=1]]', 's: [connection X1/s =>[signal: a_439_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__185__1 _185__a_76_199# _120_ _185__a_439_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_535_374# w=1]]', 'g: [connection X2/g =>[signal: a_505_21# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__185__2 _185__a_535_374# _185__a_505_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: S w=1]]', 's: [connection X3/s =>[signal: a_505_21# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__185__3 VPWR _117_ _185__a_505_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_76_199# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_535_374# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__185__4 _185__a_76_199# DUTY_CYCLE[1] _185__a_535_374# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_218_47# w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_76_199# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__185__5 _185__a_218_47# DUTY_CYCLE[1] _185__a_76_199# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_218_374# w=1]]', 'g: [connection X6/g =>[signal: A0 w=1]]', 's: [connection X6/s =>[signal: a_76_199# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__185__6 _185__a_218_374# _120_ _185__a_76_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_76_199# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__185__7 _121_ _185__a_76_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_76_199# w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__185__8 _121_ _185__a_76_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: S w=1]]', 's: [connection X9/s =>[signal: a_218_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__185__9 VGND _117_ _185__a_218_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: VGND w=1]]', 'g: [connection X10/g =>[signal: S w=1]]', 's: [connection X10/s =>[signal: a_505_21# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__185__10 VGND _117_ _185__a_505_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_439_47# w=1]]', 'g: [connection X11/g =>[signal: a_505_21# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__185__11 _185__a_439_47# _185__a_505_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _186_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__186__0 VGND _121_ _186__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__186__1 _073_ _186__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__186__2 _073_ _186__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__186__3 VPWR _121_ _186__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _187_ with the contents of sky130_fd_sc_hd__xnor2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_377_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__187__0 VPWR _100_ _187__a_377_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_377_297# w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__187__1 _187__a_377_297# _112_ _072_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: a_47_47# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__187__2 _072_ _187__a_47_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_129_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__187__3 _187__a_129_47# _100_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: B w=1]]', 's: [connection X4/s =>[signal: a_285_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__187__4 VGND _112_ _187__a_285_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_47_47# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_129_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__187__5 _187__a_47_47# _112_ _187__a_129_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: B w=1]]', 's: [connection X6/s =>[signal: a_47_47# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__187__6 VPWR _112_ _187__a_47_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_47_47# w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__187__7 _187__a_47_47# _100_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: A w=1]]', 's: [connection X8/s =>[signal: a_285_47# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__187__8 VGND _100_ _187__a_285_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_285_47# w=1]]', 'g: [connection X9/g =>[signal: a_47_47# w=1]]', 's: [connection X9/s =>[signal: Y w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__187__9 _187__a_285_47# _187__a_47_47# _072_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _188_ with the contents of sky130_fd_sc_hd__nor3_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: Y w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__188__0 _004_ counter_debounce[0] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: B w=1]]', 's: [connection X1/s =>[signal: Y w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__188__1 VGND _084_ _004_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_193_297# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__188__2 _188__a_193_297# counter_debounce[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: C w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__188__3 _004_ _089_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: Y w=1]]', 'g: [connection X4/g =>[signal: C w=1]]', 's: [connection X4/s =>[signal: a_109_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__188__4 _004_ _089_ _188__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_109_297# w=1]]', 'g: [connection X5/g =>[signal: B w=1]]', 's: [connection X5/s =>[signal: a_193_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__188__5 _188__a_109_297# _084_ _188__a_193_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _189_ with the contents of sky130_fd_sc_hd__clkbuf_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_47# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__189__0 _189__a_27_47# counter_PWM[0] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__189__1 _189__a_27_47# counter_PWM[0] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__189__2 _122_ _189__a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__189__3 VPWR _189__a_27_47# _122_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: X w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__189__4 _122_ _189__a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_27_47# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__189__5 VGND _189__a_27_47# _122_ VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _190_ with the contents of sky130_fd_sc_hd__clkbuf_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_27_47# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__190__0 _190__a_27_47# counter_PWM[1] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__190__1 _190__a_27_47# counter_PWM[1] VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__190__2 _123_ _190__a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__190__3 VPWR _190__a_27_47# _123_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: X w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__190__4 _123_ _190__a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_27_47# w=1]]', 's: [connection X5/s =>[signal: X w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__190__5 VGND _190__a_27_47# _123_ VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _191_ with the contents of sky130_fd_sc_hd__o31a_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_253_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__191__0 _191__a_253_47# _123_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: a_253_297# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__191__1 VPWR _122_ _191__a_253_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_103_199# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__191__2 _124_ _191__a_103_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_103_199# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__191__3 _124_ _191__a_103_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_253_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__191__4 VGND _122_ _191__a_253_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_103_199# w=1]]', 'g: [connection X5/g =>[signal: B1 w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__191__5 _191__a_103_199# counter_PWM[3] VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_253_47# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_103_199# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__191__6 _191__a_253_47# counter_PWM[3] _191__a_103_199# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: A3 w=1]]', 's: [connection X7/s =>[signal: a_253_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__191__7 VGND counter_PWM[2] _191__a_253_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_253_297# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: a_337_297# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__191__8 _191__a_253_297# _123_ _191__a_337_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_337_297# w=1]]', 'g: [connection X9/g =>[signal: A3 w=1]]', 's: [connection X9/s =>[signal: a_103_199# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__191__9 _191__a_337_297# counter_PWM[2] _191__a_103_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _192_ with the contents of sky130_fd_sc_hd__nor2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_109_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__192__0 _192__a_109_297# _122_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Y w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__192__1 _000_ _122_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: Y w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__192__2 VGND _124_ _000_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: a_109_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__192__3 _000_ _124_ _192__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _193_ with the contents of sky130_fd_sc_hd__a21oi_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_199_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__193__0 _193__a_199_47# _123_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_113_297# w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__193__1 _193__a_113_297# _122_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_113_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__193__2 _125_ counter_PWM[3] _193__a_113_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__193__3 VGND counter_PWM[3] _125_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A2 w=1]]', 's: [connection X4/s =>[signal: a_113_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__193__4 VPWR _123_ _193__a_113_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: Y w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_199_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__193__5 _125_ _122_ _193__a_199_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _194_ with the contents of sky130_fd_sc_hd__o21a_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_382_297# w=1]]', 'g: [connection X0/g =>[signal: A1 w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__194__0 _194__a_382_297# _122_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VGND w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: a_297_47# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__194__1 VGND _122_ _194__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_79_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_297_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__194__2 _194__a_79_21# _125_ _194__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_79_21# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__194__3 _001_ _194__a_79_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_297_47# w=1]]', 'g: [connection X4/g =>[signal: A2 w=1]]', 's: [connection X4/s =>[signal: VGND w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__194__4 _194__a_297_47# _123_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_79_21# w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_382_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__194__5 _194__a_79_21# _123_ _194__a_382_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_79_21# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__194__6 VPWR _125_ _194__a_79_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: X w=1]]', 'g: [connection X7/g =>[signal: a_79_21# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__194__7 _001_ _194__a_79_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _195_ with the contents of sky130_fd_sc_hd__a21oi_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_199_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__195__0 _195__a_199_47# _123_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_113_297# w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__195__1 _195__a_113_297# _122_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_113_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__195__2 _126_ counter_PWM[2] _195__a_113_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__195__3 VGND counter_PWM[2] _126_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A2 w=1]]', 's: [connection X4/s =>[signal: a_113_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__195__4 VPWR _123_ _195__a_113_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: Y w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_199_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__195__5 _126_ _122_ _195__a_199_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _196_ with the contents of sky130_fd_sc_hd__a31o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_80_21# w=1]]', 'g: [connection X0/g =>[signal: B1 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__196__0 _196__a_80_21# counter_PWM[3] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_80_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__196__1 _127_ _196__a_80_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_209_47# w=1]]', 'g: [connection X2/g =>[signal: A2 w=1]]', 's: [connection X2/s =>[signal: a_303_47# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__196__2 _196__a_209_47# _123_ _196__a_303_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_80_21# w=1]]', 's: [connection X3/s =>[signal: VGND w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__196__3 _127_ _196__a_80_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_303_47# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_80_21# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__196__4 _196__a_303_47# _122_ _196__a_80_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_209_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__196__5 VPWR _122_ _196__a_209_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_209_297# w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_80_21# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__196__6 _196__a_209_297# counter_PWM[3] _196__a_80_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VGND w=1]]', 'g: [connection X7/g =>[signal: A3 w=1]]', 's: [connection X7/s =>[signal: a_209_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__196__7 VGND counter_PWM[2] _196__a_209_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_209_297# w=1]]', 'g: [connection X8/g =>[signal: A2 w=1]]', 's: [connection X8/s =>[signal: VPWR w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__196__8 _196__a_209_297# _123_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VPWR w=1]]', 'g: [connection X9/g =>[signal: A3 w=1]]', 's: [connection X9/s =>[signal: a_209_297# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__196__9 VPWR counter_PWM[2] _196__a_209_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _197_ with the contents of sky130_fd_sc_hd__nor2_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_109_297# w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__197__0 _197__a_109_297# _126_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Y w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__197__1 _002_ _126_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: B w=1]]', 's: [connection X2/s =>[signal: Y w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__197__2 VGND _127_ _002_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: Y w=1]]', 'g: [connection X3/g =>[signal: B w=1]]', 's: [connection X3/s =>[signal: a_109_297# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__197__3 _002_ _127_ _197__a_109_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _198_ with the contents of sky130_fd_sc_hd__and2b_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_207_413# w=1]]', 'g: [connection X0/g =>[signal: B w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__198__0 _198__a_207_413# _127_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_207_413# w=1]]', 's: [connection X1/s =>[signal: X w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__198__1 VPWR _198__a_207_413# _128_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_207_413# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__198__2 VGND _198__a_207_413# _128_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_207_413# w=1]]', 'g: [connection X3/g =>[signal: a_27_413# w=1]]', 's: [connection X3/s =>[signal: a_297_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__198__3 _198__a_207_413# _198__a_27_413# _198__a_297_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_27_413# w=1]]', 'g: [connection X4/g =>[signal: A_N w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__198__4 _198__a_27_413# _124_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: a_27_413# w=1]]', 's: [connection X5/s =>[signal: a_207_413# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__198__5 VPWR _198__a_27_413# _198__a_207_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: A_N w=1]]', 's: [connection X6/s =>[signal: a_27_413# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__198__6 VGND _124_ _198__a_27_413# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_297_47# w=1]]', 'g: [connection X7/g =>[signal: B w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__198__7 _198__a_297_47# _127_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _199_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__199__0 VGND _128_ _199__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__199__1 _003_ _199__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__199__2 _003_ _199__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__199__3 VPWR _128_ _199__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _200_ with the contents of sky130_fd_sc_hd__a21o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_384_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__200__0 _200__a_384_47# _123_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_81_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__200__1 _129_ _200__a_81_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_81_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_299_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__200__2 _200__a_81_21# _122_ _200__a_299_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: a_81_21# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__200__3 VGND _122_ _200__a_81_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_299_297# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__200__4 _200__a_299_297# _109_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_299_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__200__5 VPWR _123_ _200__a_299_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: X w=1]]', 'g: [connection X6/g =>[signal: a_81_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__200__6 _129_ _200__a_81_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_81_21# w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_384_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__200__7 _200__a_81_21# _109_ _200__a_384_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _201_ with the contents of sky130_fd_sc_hd__o22a_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: B1 w=1]]', 's: [connection X0/s =>[signal: a_292_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__201__0 VPWR _129_ _201__a_292_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_215_47# w=1]]', 'g: [connection X1/g =>[signal: B1 w=1]]', 's: [connection X1/s =>[signal: a_78_199# w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__201__1 _201__a_215_47# _129_ _201__a_78_199# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_78_199# w=1]]', 's: [connection X2/s =>[signal: VPWR w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__201__2 _130_ _201__a_78_199# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_292_297# w=1]]', 'g: [connection X3/g =>[signal: B2 w=1]]', 's: [connection X3/s =>[signal: a_78_199# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__201__3 _201__a_292_297# _110_ _201__a_78_199# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: a_215_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__201__4 VGND _109_ _201__a_215_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_215_47# w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__201__5 _201__a_215_47# _123_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_78_199# w=1]]', 'g: [connection X6/g =>[signal: A2 w=1]]', 's: [connection X6/s =>[signal: a_493_297# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__201__6 _201__a_78_199# _123_ _201__a_493_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_493_297# w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: VPWR w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__201__7 _201__a_493_297# _109_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: X w=1]]', 'g: [connection X8/g =>[signal: a_78_199# w=1]]', 's: [connection X8/s =>[signal: VGND w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__201__8 _130_ _201__a_78_199# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_78_199# w=1]]', 'g: [connection X9/g =>[signal: B2 w=1]]', 's: [connection X9/s =>[signal: a_215_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__201__9 _201__a_78_199# _110_ _201__a_215_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _202_ with the contents of sky130_fd_sc_hd__a21o_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_384_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__202__0 _202__a_384_47# counter_PWM[2] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_81_21# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__202__1 _131_ _202__a_81_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_81_21# w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_299_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__202__2 _202__a_81_21# _130_ _202__a_299_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: a_81_21# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__202__3 VGND _130_ _202__a_81_21# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_299_297# w=1]]', 'g: [connection X4/g =>[signal: A1 w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__202__4 _202__a_299_297# _105_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VPWR w=1]]', 'g: [connection X5/g =>[signal: A2 w=1]]', 's: [connection X5/s =>[signal: a_299_297# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__202__5 VPWR counter_PWM[2] _202__a_299_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: X w=1]]', 'g: [connection X6/g =>[signal: a_81_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__202__6 _131_ _202__a_81_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_81_21# w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: a_384_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__202__7 _202__a_81_21# _105_ _202__a_384_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _203_ with the contents of sky130_fd_sc_hd__o221a_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_51_297# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: a_512_297# w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__203__0 _203__a_51_297# counter_PWM[3] _203__a_512_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_512_297# w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__203__1 _203__a_512_297# _108_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VPWR w=1]]', 'g: [connection X2/g =>[signal: a_51_297# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__203__2 VPWR _203__a_51_297# _132_ VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: a_51_297# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__203__3 VGND _203__a_51_297# _132_ VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_149_47# w=1]]', 'g: [connection X4/g =>[signal: B1 w=1]]', 's: [connection X4/s =>[signal: a_240_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__203__4 _203__a_149_47# counter_PWM[2] _203__a_240_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_51_297# w=1]]', 'g: [connection X5/g =>[signal: C1 w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__203__5 _203__a_51_297# _131_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VPWR w=1]]', 'g: [connection X6/g =>[signal: B1 w=1]]', 's: [connection X6/s =>[signal: a_245_297# w=1]]', 'b: [connection X6/b =>[signal: VPB w=1]]']]
X__203__6 VPWR counter_PWM[2] _203__a_245_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_240_47# w=1]]', 'g: [connection X7/g =>[signal: A1 w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__203__7 _203__a_240_47# _108_ VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_240_47# w=1]]', 'g: [connection X8/g =>[signal: B2 w=1]]', 's: [connection X8/s =>[signal: a_149_47# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__203__8 _203__a_240_47# _105_ _203__a_149_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A2 w=1]]', 's: [connection X9/s =>[signal: a_240_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__203__9 VGND counter_PWM[3] _203__a_240_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X10 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_245_297# w=1]]', 'g: [connection X10/g =>[signal: B2 w=1]]', 's: [connection X10/s =>[signal: a_51_297# w=1]]', 'b: [connection X10/b =>[signal: VPB w=1]]']]
X__203__10 _203__a_245_297# _105_ _203__a_51_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_51_297# w=1]]', 'g: [connection X11/g =>[signal: C1 w=1]]', 's: [connection X11/s =>[signal: a_149_47# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__203__11 _203__a_51_297# _131_ _203__a_149_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _204_ with the contents of sky130_fd_sc_hd__a21oi_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_199_47# w=1]]', 'g: [connection X0/g =>[signal: A2 w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__204__0 _204__a_199_47# counter_PWM[3] VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_113_297# w=1]]', 'g: [connection X1/g =>[signal: A1 w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__204__1 _204__a_113_297# _108_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: Y w=1]]', 'g: [connection X2/g =>[signal: B1 w=1]]', 's: [connection X2/s =>[signal: a_113_297# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__204__2 net4 _132_ _204__a_113_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: B1 w=1]]', 's: [connection X3/s =>[signal: Y w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__204__3 VGND _132_ net4 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: A2 w=1]]', 's: [connection X4/s =>[signal: a_113_297# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__204__4 VPWR counter_PWM[3] _204__a_113_297# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: Y w=1]]', 'g: [connection X5/g =>[signal: A1 w=1]]', 's: [connection X5/s =>[signal: a_199_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__204__5 net4 _108_ _204__a_199_47# VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u

** replacing _205_ with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__205__0 VGND net3 _205__a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__205__1 _133_ _205__a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__205__2 _133_ _205__a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__205__3 VPWR net3 _205__a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _206_ with the contents of sky130_fd_sc_hd__buf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__206__0 VGND _206__a_27_47# _134_ VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__206__1 _206__a_27_47# _133_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_27_47# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__206__2 _206__a_27_47# _133_ VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__206__3 VPWR _206__a_27_47# _134_ VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _217_ with the contents of sky130_fd_sc_hd__buf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__217__0 VGND _217__a_27_47# _135_ VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__217__1 _217__a_27_47# _133_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_27_47# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__217__2 _217__a_27_47# _133_ VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__217__3 VPWR _217__a_27_47# _135_ VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _228_ with the contents of sky130_fd_sc_hd__buf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__228__0 VGND _228__a_27_47# _136_ VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__228__1 _228__a_27_47# _133_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_27_47# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__228__2 _228__a_27_47# _133_ VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__228__3 VPWR _228__a_27_47# _136_ VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _239_ with the contents of sky130_fd_sc_hd__buf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X__239__0 VGND _239__a_27_47# _137_ VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__239__1 _239__a_27_47# _133_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_27_47# w=1]]', 'g: [connection X2/g =>[signal: A w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__239__2 _239__a_27_47# _133_ VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: X w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__239__3 VPWR _239__a_27_47# _137_ VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing _250_ with the contents of sky130_fd_sc_hd__dfstp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_562_413# w=1]]', 'g: [connection X0/g =>[signal: a_652_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__250__0 _250__a_562_413# _250__a_652_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1296_47# w=1]]', 'g: [connection X1/g =>[signal: SET_B w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__250__1 _250__a_1296_47# _032_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_381_47# w=1]]', 'g: [connection X2/g =>[signal: a_193_47# w=1]]', 's: [connection X2/s =>[signal: a_476_47# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__250__2 _250__a_381_47# _250__a_193_47# _250__a_476_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_1602_47# w=1]]', 'g: [connection X3/g =>[signal: a_1032_413# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__250__3 _250__a_1602_47# _250__a_1032_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1140_413# w=1]]', 'g: [connection X4/g =>[signal: a_1182_261# w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__250__4 _250__a_1140_413# _250__a_1182_261# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_1032_413# w=1]]', 'g: [connection X5/g =>[signal: a_27_47# w=1]]', 's: [connection X5/s =>[signal: a_1224_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__250__5 _250__a_1032_413# _250__a_27_47# _250__a_1224_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '540000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: a_1032_413# w=1]]', 's: [connection X6/s =>[signal: a_1182_261# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__250__6 VGND _250__a_1032_413# _250__a_1182_261# VGND sky130_fd_pr__nfet_01v8 W=540000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_476_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_562_413# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__250__7 _250__a_476_47# _250__a_27_47# _250__a_562_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_381_47# w=1]]', 'g: [connection X8/g =>[signal: a_27_47# w=1]]', 's: [connection X8/s =>[signal: a_476_47# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__250__8 _250__a_381_47# _250__a_27_47# _250__a_476_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: a_476_47# w=1]]', 's: [connection X9/s =>[signal: a_1056_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__250__9 VGND _250__a_476_47# _250__a_1056_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1602_47# w=1]]', 'g: [connection X10/g =>[signal: a_1032_413# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__250__10 _250__a_1602_47# _250__a_1032_413# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1056_47# w=1]]', 'g: [connection X11/g =>[signal: a_193_47# w=1]]', 's: [connection X11/s =>[signal: a_1032_413# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__250__11 _250__a_1056_47# _250__a_193_47# _250__a_1032_413# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: VPWR w=1]]', 'g: [connection X12/g =>[signal: SET_B w=1]]', 's: [connection X12/s =>[signal: a_652_21# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__250__12 VPWR _032_ _250__a_652_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_796_47# w=1]]', 'g: [connection X13/g =>[signal: a_476_47# w=1]]', 's: [connection X13/s =>[signal: a_652_21# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__250__13 _250__a_796_47# _250__a_476_47# _250__a_652_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: VPWR w=1]]', 'g: [connection X14/g =>[signal: a_476_47# w=1]]', 's: [connection X14/s =>[signal: a_956_413# w=1]]', 'b: [connection X14/b =>[signal: VPB w=1]]']]
X__250__14 VPWR _250__a_476_47# _250__a_956_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_586_47# w=1]]', 'g: [connection X15/g =>[signal: a_652_21# w=1]]', 's: [connection X15/s =>[signal: VGND w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__250__15 _250__a_586_47# _250__a_652_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X16 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VPWR w=1]]', 'g: [connection X16/g =>[signal: D w=1]]', 's: [connection X16/s =>[signal: a_381_47# w=1]]', 'b: [connection X16/b =>[signal: VPB w=1]]']]
X__250__16 VPWR _072_ _250__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X17 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_652_21# w=1]]', 'g: [connection X17/g =>[signal: a_476_47# w=1]]', 's: [connection X17/s =>[signal: VPWR w=1]]', 'b: [connection X17/b =>[signal: VPB w=1]]']]
X__250__17 _250__a_652_21# _250__a_476_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_1032_413# w=1]]', 'g: [connection X18/g =>[signal: a_193_47# w=1]]', 's: [connection X18/s =>[signal: a_1140_413# w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__250__18 _250__a_1032_413# _250__a_193_47# _250__a_1140_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_1602_47# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X__250__19 VGND _250__a_1602_47# DUTY_CYCLE[0] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X20 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: a_476_47# w=1]]', 'g: [connection X20/g =>[signal: a_193_47# w=1]]', 's: [connection X20/s =>[signal: a_586_47# w=1]]', 'b: [connection X20/b =>[signal: VNB w=1]]']]
X__250__20 _250__a_476_47# _250__a_193_47# _250__a_586_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1032_413# w=1]]', 'g: [connection X21/g =>[signal: SET_B w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__250__21 _250__a_1032_413# _032_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: a_27_47# w=1]]', 's: [connection X22/s =>[signal: a_193_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__250__22 VGND _250__a_27_47# _250__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: a_956_413# w=1]]', 'g: [connection X23/g =>[signal: a_27_47# w=1]]', 's: [connection X23/s =>[signal: a_1032_413# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__250__23 _250__a_956_413# _250__a_27_47# _250__a_1032_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_27_47# w=1]]', 'g: [connection X24/g =>[signal: CLK w=1]]', 's: [connection X24/s =>[signal: VGND w=1]]', 'b: [connection X24/b =>[signal: VNB w=1]]']]
X__250__24 _250__a_27_47# clknet_2_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_27_47# w=1]]', 'g: [connection X25/g =>[signal: CLK w=1]]', 's: [connection X25/s =>[signal: VPWR w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__250__25 _250__a_27_47# clknet_2_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: a_1032_413# w=1]]', 's: [connection X26/s =>[signal: a_1182_261# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__250__26 VPWR _250__a_1032_413# _250__a_1182_261# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_1224_47# w=1]]', 'g: [connection X27/g =>[signal: a_1182_261# w=1]]', 's: [connection X27/s =>[signal: a_1296_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__250__27 _250__a_1224_47# _250__a_1182_261# _250__a_1296_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_27_47# w=1]]', 's: [connection X28/s =>[signal: a_193_47# w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X__250__28 VPWR _250__a_27_47# _250__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: D w=1]]', 's: [connection X29/s =>[signal: a_381_47# w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X__250__29 VGND _072_ _250__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: VGND w=1]]', 'g: [connection X30/g =>[signal: SET_B w=1]]', 's: [connection X30/s =>[signal: a_796_47# w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X__250__30 VGND _032_ _250__a_796_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: VPWR w=1]]', 'g: [connection X31/g =>[signal: a_1602_47# w=1]]', 's: [connection X31/s =>[signal: Q w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X__250__31 VPWR _250__a_1602_47# DUTY_CYCLE[0] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _251_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__251__0 _251__a_1270_413# _251__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__251__1 VPWR _251__a_543_47# _251__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__251__2 VGND _251__a_543_47# _251__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__251__3 VGND _073_ _251__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__251__4 _251__a_1108_47# _251__a_193_47# _251__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__251__5 VGND _251__a_1283_21# DUTY_CYCLE[1] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__251__6 _251__a_1217_47# _251__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__251__7 _251__a_448_47# _251__a_27_47# _251__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__251__8 _251__a_448_47# _251__a_193_47# _251__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__251__9 _251__a_543_47# _251__a_193_47# _251__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__251__10 _251__a_1108_47# _251__a_27_47# _251__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__251__11 _251__a_1462_47# _251__a_1108_47# _251__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__251__12 _251__a_543_47# _251__a_27_47# _251__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__251__13 _251__a_805_47# _033_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__251__14 _251__a_761_289# _251__a_193_47# _251__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__251__15 VPWR _033_ _251__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__251__16 VGND _251__a_27_47# _251__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__251__17 _251__a_27_47# clknet_2_3__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__251__18 _251__a_27_47# clknet_2_3__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__251__19 VPWR _251__a_1283_21# DUTY_CYCLE[1] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__251__20 VPWR _251__a_27_47# _251__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__251__21 _251__a_1283_21# _251__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__251__22 VGND _033_ _251__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__251__23 VPWR _073_ _251__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__251__24 _251__a_651_413# _251__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__251__25 _251__a_761_289# _251__a_27_47# _251__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__251__26 VPWR _033_ _251__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__251__27 _251__a_639_47# _251__a_761_289# _251__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _252_ with the contents of sky130_fd_sc_hd__dfstp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_562_413# w=1]]', 'g: [connection X0/g =>[signal: a_652_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__252__0 _252__a_562_413# _252__a_652_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_1296_47# w=1]]', 'g: [connection X1/g =>[signal: SET_B w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__252__1 _252__a_1296_47# _034_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: a_381_47# w=1]]', 'g: [connection X2/g =>[signal: a_193_47# w=1]]', 's: [connection X2/s =>[signal: a_476_47# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__252__2 _252__a_381_47# _252__a_193_47# _252__a_476_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_1602_47# w=1]]', 'g: [connection X3/g =>[signal: a_1032_413# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X__252__3 _252__a_1602_47# _252__a_1032_413# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1140_413# w=1]]', 'g: [connection X4/g =>[signal: a_1182_261# w=1]]', 's: [connection X4/s =>[signal: VPWR w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__252__4 _252__a_1140_413# _252__a_1182_261# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_1032_413# w=1]]', 'g: [connection X5/g =>[signal: a_27_47# w=1]]', 's: [connection X5/s =>[signal: a_1224_47# w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__252__5 _252__a_1032_413# _252__a_27_47# _252__a_1224_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '540000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: a_1032_413# w=1]]', 's: [connection X6/s =>[signal: a_1182_261# w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__252__6 VGND _252__a_1032_413# _252__a_1182_261# VGND sky130_fd_pr__nfet_01v8 W=540000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_476_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_562_413# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X__252__7 _252__a_476_47# _252__a_27_47# _252__a_562_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_381_47# w=1]]', 'g: [connection X8/g =>[signal: a_27_47# w=1]]', 's: [connection X8/s =>[signal: a_476_47# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__252__8 _252__a_381_47# _252__a_27_47# _252__a_476_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: a_476_47# w=1]]', 's: [connection X9/s =>[signal: a_1056_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__252__9 VGND _252__a_476_47# _252__a_1056_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1602_47# w=1]]', 'g: [connection X10/g =>[signal: a_1032_413# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__252__10 _252__a_1602_47# _252__a_1032_413# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1056_47# w=1]]', 'g: [connection X11/g =>[signal: a_193_47# w=1]]', 's: [connection X11/s =>[signal: a_1032_413# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__252__11 _252__a_1056_47# _252__a_193_47# _252__a_1032_413# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: VPWR w=1]]', 'g: [connection X12/g =>[signal: SET_B w=1]]', 's: [connection X12/s =>[signal: a_652_21# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__252__12 VPWR _034_ _252__a_652_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_796_47# w=1]]', 'g: [connection X13/g =>[signal: a_476_47# w=1]]', 's: [connection X13/s =>[signal: a_652_21# w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__252__13 _252__a_796_47# _252__a_476_47# _252__a_652_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: VPWR w=1]]', 'g: [connection X14/g =>[signal: a_476_47# w=1]]', 's: [connection X14/s =>[signal: a_956_413# w=1]]', 'b: [connection X14/b =>[signal: VPB w=1]]']]
X__252__14 VPWR _252__a_476_47# _252__a_956_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X15 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: a_586_47# w=1]]', 'g: [connection X15/g =>[signal: a_652_21# w=1]]', 's: [connection X15/s =>[signal: VGND w=1]]', 'b: [connection X15/b =>[signal: VNB w=1]]']]
X__252__15 _252__a_586_47# _252__a_652_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X16 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VPWR w=1]]', 'g: [connection X16/g =>[signal: D w=1]]', 's: [connection X16/s =>[signal: a_381_47# w=1]]', 'b: [connection X16/b =>[signal: VPB w=1]]']]
X__252__16 VPWR _074_ _252__a_381_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X17 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_652_21# w=1]]', 'g: [connection X17/g =>[signal: a_476_47# w=1]]', 's: [connection X17/s =>[signal: VPWR w=1]]', 'b: [connection X17/b =>[signal: VPB w=1]]']]
X__252__17 _252__a_652_21# _252__a_476_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_1032_413# w=1]]', 'g: [connection X18/g =>[signal: a_193_47# w=1]]', 's: [connection X18/s =>[signal: a_1140_413# w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__252__18 _252__a_1032_413# _252__a_193_47# _252__a_1140_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_1602_47# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X__252__19 VGND _252__a_1602_47# DUTY_CYCLE[2] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X20 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: a_476_47# w=1]]', 'g: [connection X20/g =>[signal: a_193_47# w=1]]', 's: [connection X20/s =>[signal: a_586_47# w=1]]', 'b: [connection X20/b =>[signal: VNB w=1]]']]
X__252__20 _252__a_476_47# _252__a_193_47# _252__a_586_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1032_413# w=1]]', 'g: [connection X21/g =>[signal: SET_B w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__252__21 _252__a_1032_413# _034_ VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: a_27_47# w=1]]', 's: [connection X22/s =>[signal: a_193_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__252__22 VGND _252__a_27_47# _252__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: a_956_413# w=1]]', 'g: [connection X23/g =>[signal: a_27_47# w=1]]', 's: [connection X23/s =>[signal: a_1032_413# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__252__23 _252__a_956_413# _252__a_27_47# _252__a_1032_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_27_47# w=1]]', 'g: [connection X24/g =>[signal: CLK w=1]]', 's: [connection X24/s =>[signal: VGND w=1]]', 'b: [connection X24/b =>[signal: VNB w=1]]']]
X__252__24 _252__a_27_47# clknet_2_3__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_27_47# w=1]]', 'g: [connection X25/g =>[signal: CLK w=1]]', 's: [connection X25/s =>[signal: VPWR w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__252__25 _252__a_27_47# clknet_2_3__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: a_1032_413# w=1]]', 's: [connection X26/s =>[signal: a_1182_261# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__252__26 VPWR _252__a_1032_413# _252__a_1182_261# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_1224_47# w=1]]', 'g: [connection X27/g =>[signal: a_1182_261# w=1]]', 's: [connection X27/s =>[signal: a_1296_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__252__27 _252__a_1224_47# _252__a_1182_261# _252__a_1296_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_27_47# w=1]]', 's: [connection X28/s =>[signal: a_193_47# w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X__252__28 VPWR _252__a_27_47# _252__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: D w=1]]', 's: [connection X29/s =>[signal: a_381_47# w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X__252__29 VGND _074_ _252__a_381_47# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: VGND w=1]]', 'g: [connection X30/g =>[signal: SET_B w=1]]', 's: [connection X30/s =>[signal: a_796_47# w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X__252__30 VGND _034_ _252__a_796_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: VPWR w=1]]', 'g: [connection X31/g =>[signal: a_1602_47# w=1]]', 's: [connection X31/s =>[signal: Q w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X__252__31 VPWR _252__a_1602_47# DUTY_CYCLE[2] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u

** replacing _253_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__253__0 _253__a_1270_413# _253__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__253__1 VPWR _253__a_543_47# _253__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__253__2 VGND _253__a_543_47# _253__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__253__3 VGND _075_ _253__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__253__4 _253__a_1108_47# _253__a_193_47# _253__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__253__5 VGND _253__a_1283_21# DUTY_CYCLE[3] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__253__6 _253__a_1217_47# _253__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__253__7 _253__a_448_47# _253__a_27_47# _253__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__253__8 _253__a_448_47# _253__a_193_47# _253__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__253__9 _253__a_543_47# _253__a_193_47# _253__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__253__10 _253__a_1108_47# _253__a_27_47# _253__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__253__11 _253__a_1462_47# _253__a_1108_47# _253__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__253__12 _253__a_543_47# _253__a_27_47# _253__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__253__13 _253__a_805_47# _035_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__253__14 _253__a_761_289# _253__a_193_47# _253__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__253__15 VPWR _035_ _253__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__253__16 VGND _253__a_27_47# _253__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__253__17 _253__a_27_47# clknet_2_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__253__18 _253__a_27_47# clknet_2_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__253__19 VPWR _253__a_1283_21# DUTY_CYCLE[3] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__253__20 VPWR _253__a_27_47# _253__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__253__21 _253__a_1283_21# _253__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__253__22 VGND _035_ _253__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__253__23 VPWR _075_ _253__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__253__24 _253__a_651_413# _253__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__253__25 _253__a_761_289# _253__a_27_47# _253__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__253__26 VPWR _035_ _253__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__253__27 _253__a_639_47# _253__a_761_289# _253__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _254_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__254__0 _254__a_1270_413# _254__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__254__1 VPWR _254__a_543_47# _254__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__254__2 VGND _254__a_543_47# _254__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__254__3 VGND _004_ _254__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__254__4 _254__a_1108_47# _254__a_193_47# _254__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__254__5 VGND _254__a_1283_21# counter_debounce[0] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__254__6 _254__a_1217_47# _254__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__254__7 _254__a_448_47# _254__a_27_47# _254__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__254__8 _254__a_448_47# _254__a_193_47# _254__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__254__9 _254__a_543_47# _254__a_193_47# _254__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__254__10 _254__a_1108_47# _254__a_27_47# _254__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__254__11 _254__a_1462_47# _254__a_1108_47# _254__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__254__12 _254__a_543_47# _254__a_27_47# _254__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__254__13 _254__a_805_47# _036_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__254__14 _254__a_761_289# _254__a_193_47# _254__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__254__15 VPWR _036_ _254__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__254__16 VGND _254__a_27_47# _254__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__254__17 _254__a_27_47# clknet_2_3__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__254__18 _254__a_27_47# clknet_2_3__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__254__19 VPWR _254__a_1283_21# counter_debounce[0] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__254__20 VPWR _254__a_27_47# _254__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__254__21 _254__a_1283_21# _254__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__254__22 VGND _036_ _254__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__254__23 VPWR _004_ _254__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__254__24 _254__a_651_413# _254__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__254__25 _254__a_761_289# _254__a_27_47# _254__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__254__26 VPWR _036_ _254__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__254__27 _254__a_639_47# _254__a_761_289# _254__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _255_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__255__0 _255__a_1270_413# _255__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__255__1 VPWR _255__a_543_47# _255__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__255__2 VGND _255__a_543_47# _255__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__255__3 VGND net31 _255__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__255__4 _255__a_1108_47# _255__a_193_47# _255__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__255__5 VGND _255__a_1283_21# counter_debounce[1] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__255__6 _255__a_1217_47# _255__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__255__7 _255__a_448_47# _255__a_27_47# _255__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__255__8 _255__a_448_47# _255__a_193_47# _255__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__255__9 _255__a_543_47# _255__a_193_47# _255__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__255__10 _255__a_1108_47# _255__a_27_47# _255__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__255__11 _255__a_1462_47# _255__a_1108_47# _255__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__255__12 _255__a_543_47# _255__a_27_47# _255__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__255__13 _255__a_805_47# _037_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__255__14 _255__a_761_289# _255__a_193_47# _255__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__255__15 VPWR _037_ _255__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__255__16 VGND _255__a_27_47# _255__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__255__17 _255__a_27_47# clknet_2_2__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__255__18 _255__a_27_47# clknet_2_2__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__255__19 VPWR _255__a_1283_21# counter_debounce[1] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__255__20 VPWR _255__a_27_47# _255__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__255__21 _255__a_1283_21# _255__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__255__22 VGND _037_ _255__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__255__23 VPWR net31 _255__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__255__24 _255__a_651_413# _255__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__255__25 _255__a_761_289# _255__a_27_47# _255__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__255__26 VPWR _037_ _255__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__255__27 _255__a_639_47# _255__a_761_289# _255__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _255__31 with the contents of sky130_fd_sc_hd__conb_1

** replacing _256_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__256__0 _256__a_1270_413# _256__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__256__1 VPWR _256__a_543_47# _256__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__256__2 VGND _256__a_543_47# _256__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__256__3 VGND net30 _256__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__256__4 _256__a_1108_47# _256__a_193_47# _256__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__256__5 VGND _256__a_1283_21# counter_debounce[2] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__256__6 _256__a_1217_47# _256__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__256__7 _256__a_448_47# _256__a_27_47# _256__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__256__8 _256__a_448_47# _256__a_193_47# _256__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__256__9 _256__a_543_47# _256__a_193_47# _256__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__256__10 _256__a_1108_47# _256__a_27_47# _256__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__256__11 _256__a_1462_47# _256__a_1108_47# _256__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__256__12 _256__a_543_47# _256__a_27_47# _256__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__256__13 _256__a_805_47# _038_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__256__14 _256__a_761_289# _256__a_193_47# _256__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__256__15 VPWR _038_ _256__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__256__16 VGND _256__a_27_47# _256__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__256__17 _256__a_27_47# clknet_2_2__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__256__18 _256__a_27_47# clknet_2_2__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__256__19 VPWR _256__a_1283_21# counter_debounce[2] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__256__20 VPWR _256__a_27_47# _256__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__256__21 _256__a_1283_21# _256__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__256__22 VGND _038_ _256__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__256__23 VPWR net30 _256__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__256__24 _256__a_651_413# _256__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__256__25 _256__a_761_289# _256__a_27_47# _256__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__256__26 VPWR _038_ _256__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__256__27 _256__a_639_47# _256__a_761_289# _256__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _256__30 with the contents of sky130_fd_sc_hd__conb_1

** replacing _257_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__257__0 _257__a_1270_413# _257__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__257__1 VPWR _257__a_543_47# _257__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__257__2 VGND _257__a_543_47# _257__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__257__3 VGND net29 _257__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__257__4 _257__a_1108_47# _257__a_193_47# _257__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__257__5 VGND _257__a_1283_21# counter_debounce[3] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__257__6 _257__a_1217_47# _257__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__257__7 _257__a_448_47# _257__a_27_47# _257__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__257__8 _257__a_448_47# _257__a_193_47# _257__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__257__9 _257__a_543_47# _257__a_193_47# _257__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__257__10 _257__a_1108_47# _257__a_27_47# _257__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__257__11 _257__a_1462_47# _257__a_1108_47# _257__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__257__12 _257__a_543_47# _257__a_27_47# _257__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__257__13 _257__a_805_47# _039_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__257__14 _257__a_761_289# _257__a_193_47# _257__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__257__15 VPWR _039_ _257__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__257__16 VGND _257__a_27_47# _257__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__257__17 _257__a_27_47# clknet_2_3__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__257__18 _257__a_27_47# clknet_2_3__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__257__19 VPWR _257__a_1283_21# counter_debounce[3] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__257__20 VPWR _257__a_27_47# _257__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__257__21 _257__a_1283_21# _257__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__257__22 VGND _039_ _257__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__257__23 VPWR net29 _257__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__257__24 _257__a_651_413# _257__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__257__25 _257__a_761_289# _257__a_27_47# _257__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__257__26 VPWR _039_ _257__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__257__27 _257__a_639_47# _257__a_761_289# _257__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _257__29 with the contents of sky130_fd_sc_hd__conb_1

** replacing _258_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__258__0 _258__a_1270_413# _258__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__258__1 VPWR _258__a_543_47# _258__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__258__2 VGND _258__a_543_47# _258__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__258__3 VGND net28 _258__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__258__4 _258__a_1108_47# _258__a_193_47# _258__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__258__5 VGND _258__a_1283_21# counter_debounce[4] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__258__6 _258__a_1217_47# _258__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__258__7 _258__a_448_47# _258__a_27_47# _258__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__258__8 _258__a_448_47# _258__a_193_47# _258__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__258__9 _258__a_543_47# _258__a_193_47# _258__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__258__10 _258__a_1108_47# _258__a_27_47# _258__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__258__11 _258__a_1462_47# _258__a_1108_47# _258__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__258__12 _258__a_543_47# _258__a_27_47# _258__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__258__13 _258__a_805_47# _040_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__258__14 _258__a_761_289# _258__a_193_47# _258__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__258__15 VPWR _040_ _258__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__258__16 VGND _258__a_27_47# _258__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__258__17 _258__a_27_47# clknet_2_2__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__258__18 _258__a_27_47# clknet_2_2__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__258__19 VPWR _258__a_1283_21# counter_debounce[4] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__258__20 VPWR _258__a_27_47# _258__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__258__21 _258__a_1283_21# _258__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__258__22 VGND _040_ _258__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__258__23 VPWR net28 _258__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__258__24 _258__a_651_413# _258__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__258__25 _258__a_761_289# _258__a_27_47# _258__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__258__26 VPWR _040_ _258__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__258__27 _258__a_639_47# _258__a_761_289# _258__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _258__28 with the contents of sky130_fd_sc_hd__conb_1

** replacing _259_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__259__0 _259__a_1270_413# _259__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__259__1 VPWR _259__a_543_47# _259__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__259__2 VGND _259__a_543_47# _259__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__259__3 VGND net27 _259__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__259__4 _259__a_1108_47# _259__a_193_47# _259__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__259__5 VGND _259__a_1283_21# counter_debounce[5] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__259__6 _259__a_1217_47# _259__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__259__7 _259__a_448_47# _259__a_27_47# _259__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__259__8 _259__a_448_47# _259__a_193_47# _259__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__259__9 _259__a_543_47# _259__a_193_47# _259__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__259__10 _259__a_1108_47# _259__a_27_47# _259__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__259__11 _259__a_1462_47# _259__a_1108_47# _259__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__259__12 _259__a_543_47# _259__a_27_47# _259__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__259__13 _259__a_805_47# _041_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__259__14 _259__a_761_289# _259__a_193_47# _259__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__259__15 VPWR _041_ _259__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__259__16 VGND _259__a_27_47# _259__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__259__17 _259__a_27_47# clknet_2_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__259__18 _259__a_27_47# clknet_2_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__259__19 VPWR _259__a_1283_21# counter_debounce[5] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__259__20 VPWR _259__a_27_47# _259__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__259__21 _259__a_1283_21# _259__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__259__22 VGND _041_ _259__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__259__23 VPWR net27 _259__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__259__24 _259__a_651_413# _259__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__259__25 _259__a_761_289# _259__a_27_47# _259__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__259__26 VPWR _041_ _259__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__259__27 _259__a_639_47# _259__a_761_289# _259__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _259__27 with the contents of sky130_fd_sc_hd__conb_1

** replacing _260_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__260__0 _260__a_1270_413# _260__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__260__1 VPWR _260__a_543_47# _260__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__260__2 VGND _260__a_543_47# _260__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__260__3 VGND net26 _260__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__260__4 _260__a_1108_47# _260__a_193_47# _260__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__260__5 VGND _260__a_1283_21# counter_debounce[6] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__260__6 _260__a_1217_47# _260__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__260__7 _260__a_448_47# _260__a_27_47# _260__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__260__8 _260__a_448_47# _260__a_193_47# _260__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__260__9 _260__a_543_47# _260__a_193_47# _260__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__260__10 _260__a_1108_47# _260__a_27_47# _260__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__260__11 _260__a_1462_47# _260__a_1108_47# _260__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__260__12 _260__a_543_47# _260__a_27_47# _260__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__260__13 _260__a_805_47# _042_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__260__14 _260__a_761_289# _260__a_193_47# _260__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__260__15 VPWR _042_ _260__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__260__16 VGND _260__a_27_47# _260__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__260__17 _260__a_27_47# clknet_2_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__260__18 _260__a_27_47# clknet_2_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__260__19 VPWR _260__a_1283_21# counter_debounce[6] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__260__20 VPWR _260__a_27_47# _260__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__260__21 _260__a_1283_21# _260__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__260__22 VGND _042_ _260__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__260__23 VPWR net26 _260__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__260__24 _260__a_651_413# _260__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__260__25 _260__a_761_289# _260__a_27_47# _260__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__260__26 VPWR _042_ _260__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__260__27 _260__a_639_47# _260__a_761_289# _260__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _260__26 with the contents of sky130_fd_sc_hd__conb_1

** replacing _261_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__261__0 _261__a_1270_413# _261__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__261__1 VPWR _261__a_543_47# _261__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__261__2 VGND _261__a_543_47# _261__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__261__3 VGND net25 _261__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__261__4 _261__a_1108_47# _261__a_193_47# _261__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__261__5 VGND _261__a_1283_21# counter_debounce[7] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__261__6 _261__a_1217_47# _261__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__261__7 _261__a_448_47# _261__a_27_47# _261__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__261__8 _261__a_448_47# _261__a_193_47# _261__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__261__9 _261__a_543_47# _261__a_193_47# _261__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__261__10 _261__a_1108_47# _261__a_27_47# _261__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__261__11 _261__a_1462_47# _261__a_1108_47# _261__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__261__12 _261__a_543_47# _261__a_27_47# _261__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__261__13 _261__a_805_47# _043_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__261__14 _261__a_761_289# _261__a_193_47# _261__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__261__15 VPWR _043_ _261__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__261__16 VGND _261__a_27_47# _261__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__261__17 _261__a_27_47# clknet_2_2__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__261__18 _261__a_27_47# clknet_2_2__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__261__19 VPWR _261__a_1283_21# counter_debounce[7] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__261__20 VPWR _261__a_27_47# _261__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__261__21 _261__a_1283_21# _261__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__261__22 VGND _043_ _261__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__261__23 VPWR net25 _261__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__261__24 _261__a_651_413# _261__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__261__25 _261__a_761_289# _261__a_27_47# _261__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__261__26 VPWR _043_ _261__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__261__27 _261__a_639_47# _261__a_761_289# _261__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _261__25 with the contents of sky130_fd_sc_hd__conb_1

** replacing _262_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__262__0 _262__a_1270_413# _262__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__262__1 VPWR _262__a_543_47# _262__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__262__2 VGND _262__a_543_47# _262__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__262__3 VGND net24 _262__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__262__4 _262__a_1108_47# _262__a_193_47# _262__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__262__5 VGND _262__a_1283_21# counter_debounce[8] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__262__6 _262__a_1217_47# _262__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__262__7 _262__a_448_47# _262__a_27_47# _262__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__262__8 _262__a_448_47# _262__a_193_47# _262__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__262__9 _262__a_543_47# _262__a_193_47# _262__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__262__10 _262__a_1108_47# _262__a_27_47# _262__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__262__11 _262__a_1462_47# _262__a_1108_47# _262__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__262__12 _262__a_543_47# _262__a_27_47# _262__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__262__13 _262__a_805_47# _044_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__262__14 _262__a_761_289# _262__a_193_47# _262__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__262__15 VPWR _044_ _262__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__262__16 VGND _262__a_27_47# _262__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__262__17 _262__a_27_47# clknet_2_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__262__18 _262__a_27_47# clknet_2_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__262__19 VPWR _262__a_1283_21# counter_debounce[8] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__262__20 VPWR _262__a_27_47# _262__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__262__21 _262__a_1283_21# _262__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__262__22 VGND _044_ _262__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__262__23 VPWR net24 _262__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__262__24 _262__a_651_413# _262__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__262__25 _262__a_761_289# _262__a_27_47# _262__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__262__26 VPWR _044_ _262__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__262__27 _262__a_639_47# _262__a_761_289# _262__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _262__24 with the contents of sky130_fd_sc_hd__conb_1

** replacing _263_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__263__0 _263__a_1270_413# _263__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__263__1 VPWR _263__a_543_47# _263__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__263__2 VGND _263__a_543_47# _263__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__263__3 VGND net23 _263__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__263__4 _263__a_1108_47# _263__a_193_47# _263__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__263__5 VGND _263__a_1283_21# counter_debounce[9] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__263__6 _263__a_1217_47# _263__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__263__7 _263__a_448_47# _263__a_27_47# _263__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__263__8 _263__a_448_47# _263__a_193_47# _263__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__263__9 _263__a_543_47# _263__a_193_47# _263__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__263__10 _263__a_1108_47# _263__a_27_47# _263__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__263__11 _263__a_1462_47# _263__a_1108_47# _263__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__263__12 _263__a_543_47# _263__a_27_47# _263__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__263__13 _263__a_805_47# _045_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__263__14 _263__a_761_289# _263__a_193_47# _263__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__263__15 VPWR _045_ _263__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__263__16 VGND _263__a_27_47# _263__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__263__17 _263__a_27_47# clknet_2_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__263__18 _263__a_27_47# clknet_2_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__263__19 VPWR _263__a_1283_21# counter_debounce[9] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__263__20 VPWR _263__a_27_47# _263__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__263__21 _263__a_1283_21# _263__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__263__22 VGND _045_ _263__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__263__23 VPWR net23 _263__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__263__24 _263__a_651_413# _263__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__263__25 _263__a_761_289# _263__a_27_47# _263__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__263__26 VPWR _045_ _263__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__263__27 _263__a_639_47# _263__a_761_289# _263__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _263__23 with the contents of sky130_fd_sc_hd__conb_1

** replacing _264_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__264__0 _264__a_1270_413# _264__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__264__1 VPWR _264__a_543_47# _264__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__264__2 VGND _264__a_543_47# _264__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__264__3 VGND net22 _264__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__264__4 _264__a_1108_47# _264__a_193_47# _264__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__264__5 VGND _264__a_1283_21# counter_debounce[10] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__264__6 _264__a_1217_47# _264__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__264__7 _264__a_448_47# _264__a_27_47# _264__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__264__8 _264__a_448_47# _264__a_193_47# _264__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__264__9 _264__a_543_47# _264__a_193_47# _264__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__264__10 _264__a_1108_47# _264__a_27_47# _264__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__264__11 _264__a_1462_47# _264__a_1108_47# _264__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__264__12 _264__a_543_47# _264__a_27_47# _264__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__264__13 _264__a_805_47# _046_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__264__14 _264__a_761_289# _264__a_193_47# _264__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__264__15 VPWR _046_ _264__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__264__16 VGND _264__a_27_47# _264__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__264__17 _264__a_27_47# clknet_2_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__264__18 _264__a_27_47# clknet_2_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__264__19 VPWR _264__a_1283_21# counter_debounce[10] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__264__20 VPWR _264__a_27_47# _264__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__264__21 _264__a_1283_21# _264__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__264__22 VGND _046_ _264__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__264__23 VPWR net22 _264__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__264__24 _264__a_651_413# _264__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__264__25 _264__a_761_289# _264__a_27_47# _264__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__264__26 VPWR _046_ _264__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__264__27 _264__a_639_47# _264__a_761_289# _264__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _264__22 with the contents of sky130_fd_sc_hd__conb_1

** replacing _265_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__265__0 _265__a_1270_413# _265__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__265__1 VPWR _265__a_543_47# _265__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__265__2 VGND _265__a_543_47# _265__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__265__3 VGND net21 _265__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__265__4 _265__a_1108_47# _265__a_193_47# _265__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__265__5 VGND _265__a_1283_21# counter_debounce[11] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__265__6 _265__a_1217_47# _265__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__265__7 _265__a_448_47# _265__a_27_47# _265__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__265__8 _265__a_448_47# _265__a_193_47# _265__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__265__9 _265__a_543_47# _265__a_193_47# _265__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__265__10 _265__a_1108_47# _265__a_27_47# _265__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__265__11 _265__a_1462_47# _265__a_1108_47# _265__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__265__12 _265__a_543_47# _265__a_27_47# _265__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__265__13 _265__a_805_47# _047_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__265__14 _265__a_761_289# _265__a_193_47# _265__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__265__15 VPWR _047_ _265__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__265__16 VGND _265__a_27_47# _265__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__265__17 _265__a_27_47# clknet_2_3__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__265__18 _265__a_27_47# clknet_2_3__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__265__19 VPWR _265__a_1283_21# counter_debounce[11] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__265__20 VPWR _265__a_27_47# _265__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__265__21 _265__a_1283_21# _265__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__265__22 VGND _047_ _265__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__265__23 VPWR net21 _265__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__265__24 _265__a_651_413# _265__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__265__25 _265__a_761_289# _265__a_27_47# _265__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__265__26 VPWR _047_ _265__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__265__27 _265__a_639_47# _265__a_761_289# _265__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _265__21 with the contents of sky130_fd_sc_hd__conb_1

** replacing _266_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__266__0 _266__a_1270_413# _266__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__266__1 VPWR _266__a_543_47# _266__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__266__2 VGND _266__a_543_47# _266__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__266__3 VGND net20 _266__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__266__4 _266__a_1108_47# _266__a_193_47# _266__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__266__5 VGND _266__a_1283_21# counter_debounce[12] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__266__6 _266__a_1217_47# _266__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__266__7 _266__a_448_47# _266__a_27_47# _266__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__266__8 _266__a_448_47# _266__a_193_47# _266__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__266__9 _266__a_543_47# _266__a_193_47# _266__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__266__10 _266__a_1108_47# _266__a_27_47# _266__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__266__11 _266__a_1462_47# _266__a_1108_47# _266__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__266__12 _266__a_543_47# _266__a_27_47# _266__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__266__13 _266__a_805_47# _048_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__266__14 _266__a_761_289# _266__a_193_47# _266__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__266__15 VPWR _048_ _266__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__266__16 VGND _266__a_27_47# _266__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__266__17 _266__a_27_47# clknet_2_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__266__18 _266__a_27_47# clknet_2_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__266__19 VPWR _266__a_1283_21# counter_debounce[12] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__266__20 VPWR _266__a_27_47# _266__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__266__21 _266__a_1283_21# _266__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__266__22 VGND _048_ _266__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__266__23 VPWR net20 _266__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__266__24 _266__a_651_413# _266__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__266__25 _266__a_761_289# _266__a_27_47# _266__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__266__26 VPWR _048_ _266__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__266__27 _266__a_639_47# _266__a_761_289# _266__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _266__20 with the contents of sky130_fd_sc_hd__conb_1

** replacing _267_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__267__0 _267__a_1270_413# _267__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__267__1 VPWR _267__a_543_47# _267__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__267__2 VGND _267__a_543_47# _267__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__267__3 VGND net19 _267__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__267__4 _267__a_1108_47# _267__a_193_47# _267__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__267__5 VGND _267__a_1283_21# counter_debounce[13] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__267__6 _267__a_1217_47# _267__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__267__7 _267__a_448_47# _267__a_27_47# _267__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__267__8 _267__a_448_47# _267__a_193_47# _267__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__267__9 _267__a_543_47# _267__a_193_47# _267__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__267__10 _267__a_1108_47# _267__a_27_47# _267__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__267__11 _267__a_1462_47# _267__a_1108_47# _267__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__267__12 _267__a_543_47# _267__a_27_47# _267__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__267__13 _267__a_805_47# _049_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__267__14 _267__a_761_289# _267__a_193_47# _267__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__267__15 VPWR _049_ _267__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__267__16 VGND _267__a_27_47# _267__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__267__17 _267__a_27_47# clknet_2_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__267__18 _267__a_27_47# clknet_2_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__267__19 VPWR _267__a_1283_21# counter_debounce[13] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__267__20 VPWR _267__a_27_47# _267__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__267__21 _267__a_1283_21# _267__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__267__22 VGND _049_ _267__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__267__23 VPWR net19 _267__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__267__24 _267__a_651_413# _267__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__267__25 _267__a_761_289# _267__a_27_47# _267__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__267__26 VPWR _049_ _267__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__267__27 _267__a_639_47# _267__a_761_289# _267__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _267__19 with the contents of sky130_fd_sc_hd__conb_1

** replacing _268_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__268__0 _268__a_1270_413# _268__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__268__1 VPWR _268__a_543_47# _268__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__268__2 VGND _268__a_543_47# _268__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__268__3 VGND net18 _268__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__268__4 _268__a_1108_47# _268__a_193_47# _268__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__268__5 VGND _268__a_1283_21# counter_debounce[14] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__268__6 _268__a_1217_47# _268__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__268__7 _268__a_448_47# _268__a_27_47# _268__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__268__8 _268__a_448_47# _268__a_193_47# _268__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__268__9 _268__a_543_47# _268__a_193_47# _268__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__268__10 _268__a_1108_47# _268__a_27_47# _268__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__268__11 _268__a_1462_47# _268__a_1108_47# _268__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__268__12 _268__a_543_47# _268__a_27_47# _268__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__268__13 _268__a_805_47# _050_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__268__14 _268__a_761_289# _268__a_193_47# _268__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__268__15 VPWR _050_ _268__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__268__16 VGND _268__a_27_47# _268__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__268__17 _268__a_27_47# clknet_2_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__268__18 _268__a_27_47# clknet_2_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__268__19 VPWR _268__a_1283_21# counter_debounce[14] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__268__20 VPWR _268__a_27_47# _268__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__268__21 _268__a_1283_21# _268__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__268__22 VGND _050_ _268__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__268__23 VPWR net18 _268__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__268__24 _268__a_651_413# _268__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__268__25 _268__a_761_289# _268__a_27_47# _268__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__268__26 VPWR _050_ _268__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__268__27 _268__a_639_47# _268__a_761_289# _268__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _268__18 with the contents of sky130_fd_sc_hd__conb_1

** replacing _269_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__269__0 _269__a_1270_413# _269__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__269__1 VPWR _269__a_543_47# _269__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__269__2 VGND _269__a_543_47# _269__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__269__3 VGND net17 _269__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__269__4 _269__a_1108_47# _269__a_193_47# _269__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__269__5 VGND _269__a_1283_21# counter_debounce[15] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__269__6 _269__a_1217_47# _269__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__269__7 _269__a_448_47# _269__a_27_47# _269__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__269__8 _269__a_448_47# _269__a_193_47# _269__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__269__9 _269__a_543_47# _269__a_193_47# _269__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__269__10 _269__a_1108_47# _269__a_27_47# _269__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__269__11 _269__a_1462_47# _269__a_1108_47# _269__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__269__12 _269__a_543_47# _269__a_27_47# _269__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__269__13 _269__a_805_47# _051_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__269__14 _269__a_761_289# _269__a_193_47# _269__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__269__15 VPWR _051_ _269__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__269__16 VGND _269__a_27_47# _269__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__269__17 _269__a_27_47# clknet_2_2__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__269__18 _269__a_27_47# clknet_2_2__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__269__19 VPWR _269__a_1283_21# counter_debounce[15] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__269__20 VPWR _269__a_27_47# _269__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__269__21 _269__a_1283_21# _269__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__269__22 VGND _051_ _269__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__269__23 VPWR net17 _269__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__269__24 _269__a_651_413# _269__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__269__25 _269__a_761_289# _269__a_27_47# _269__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__269__26 VPWR _051_ _269__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__269__27 _269__a_639_47# _269__a_761_289# _269__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _269__17 with the contents of sky130_fd_sc_hd__conb_1

** replacing _270_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__270__0 _270__a_1270_413# _270__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__270__1 VPWR _270__a_543_47# _270__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__270__2 VGND _270__a_543_47# _270__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__270__3 VGND net16 _270__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__270__4 _270__a_1108_47# _270__a_193_47# _270__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__270__5 VGND _270__a_1283_21# counter_debounce[16] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__270__6 _270__a_1217_47# _270__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__270__7 _270__a_448_47# _270__a_27_47# _270__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__270__8 _270__a_448_47# _270__a_193_47# _270__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__270__9 _270__a_543_47# _270__a_193_47# _270__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__270__10 _270__a_1108_47# _270__a_27_47# _270__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__270__11 _270__a_1462_47# _270__a_1108_47# _270__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__270__12 _270__a_543_47# _270__a_27_47# _270__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__270__13 _270__a_805_47# _052_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__270__14 _270__a_761_289# _270__a_193_47# _270__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__270__15 VPWR _052_ _270__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__270__16 VGND _270__a_27_47# _270__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__270__17 _270__a_27_47# clknet_2_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__270__18 _270__a_27_47# clknet_2_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__270__19 VPWR _270__a_1283_21# counter_debounce[16] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__270__20 VPWR _270__a_27_47# _270__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__270__21 _270__a_1283_21# _270__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__270__22 VGND _052_ _270__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__270__23 VPWR net16 _270__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__270__24 _270__a_651_413# _270__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__270__25 _270__a_761_289# _270__a_27_47# _270__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__270__26 VPWR _052_ _270__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__270__27 _270__a_639_47# _270__a_761_289# _270__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _270__16 with the contents of sky130_fd_sc_hd__conb_1

** replacing _271_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__271__0 _271__a_1270_413# _271__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__271__1 VPWR _271__a_543_47# _271__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__271__2 VGND _271__a_543_47# _271__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__271__3 VGND net15 _271__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__271__4 _271__a_1108_47# _271__a_193_47# _271__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__271__5 VGND _271__a_1283_21# counter_debounce[17] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__271__6 _271__a_1217_47# _271__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__271__7 _271__a_448_47# _271__a_27_47# _271__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__271__8 _271__a_448_47# _271__a_193_47# _271__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__271__9 _271__a_543_47# _271__a_193_47# _271__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__271__10 _271__a_1108_47# _271__a_27_47# _271__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__271__11 _271__a_1462_47# _271__a_1108_47# _271__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__271__12 _271__a_543_47# _271__a_27_47# _271__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__271__13 _271__a_805_47# _053_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__271__14 _271__a_761_289# _271__a_193_47# _271__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__271__15 VPWR _053_ _271__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__271__16 VGND _271__a_27_47# _271__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__271__17 _271__a_27_47# clknet_2_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__271__18 _271__a_27_47# clknet_2_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__271__19 VPWR _271__a_1283_21# counter_debounce[17] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__271__20 VPWR _271__a_27_47# _271__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__271__21 _271__a_1283_21# _271__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__271__22 VGND _053_ _271__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__271__23 VPWR net15 _271__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__271__24 _271__a_651_413# _271__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__271__25 _271__a_761_289# _271__a_27_47# _271__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__271__26 VPWR _053_ _271__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__271__27 _271__a_639_47# _271__a_761_289# _271__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _271__15 with the contents of sky130_fd_sc_hd__conb_1

** replacing _272_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__272__0 _272__a_1270_413# _272__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__272__1 VPWR _272__a_543_47# _272__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__272__2 VGND _272__a_543_47# _272__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__272__3 VGND net14 _272__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__272__4 _272__a_1108_47# _272__a_193_47# _272__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__272__5 VGND _272__a_1283_21# counter_debounce[18] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__272__6 _272__a_1217_47# _272__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__272__7 _272__a_448_47# _272__a_27_47# _272__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__272__8 _272__a_448_47# _272__a_193_47# _272__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__272__9 _272__a_543_47# _272__a_193_47# _272__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__272__10 _272__a_1108_47# _272__a_27_47# _272__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__272__11 _272__a_1462_47# _272__a_1108_47# _272__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__272__12 _272__a_543_47# _272__a_27_47# _272__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__272__13 _272__a_805_47# _054_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__272__14 _272__a_761_289# _272__a_193_47# _272__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__272__15 VPWR _054_ _272__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__272__16 VGND _272__a_27_47# _272__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__272__17 _272__a_27_47# clknet_2_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__272__18 _272__a_27_47# clknet_2_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__272__19 VPWR _272__a_1283_21# counter_debounce[18] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__272__20 VPWR _272__a_27_47# _272__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__272__21 _272__a_1283_21# _272__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__272__22 VGND _054_ _272__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__272__23 VPWR net14 _272__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__272__24 _272__a_651_413# _272__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__272__25 _272__a_761_289# _272__a_27_47# _272__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__272__26 VPWR _054_ _272__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__272__27 _272__a_639_47# _272__a_761_289# _272__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _272__14 with the contents of sky130_fd_sc_hd__conb_1

** replacing _273_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__273__0 _273__a_1270_413# _273__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__273__1 VPWR _273__a_543_47# _273__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__273__2 VGND _273__a_543_47# _273__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__273__3 VGND net13 _273__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__273__4 _273__a_1108_47# _273__a_193_47# _273__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__273__5 VGND _273__a_1283_21# counter_debounce[19] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__273__6 _273__a_1217_47# _273__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__273__7 _273__a_448_47# _273__a_27_47# _273__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__273__8 _273__a_448_47# _273__a_193_47# _273__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__273__9 _273__a_543_47# _273__a_193_47# _273__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__273__10 _273__a_1108_47# _273__a_27_47# _273__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__273__11 _273__a_1462_47# _273__a_1108_47# _273__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__273__12 _273__a_543_47# _273__a_27_47# _273__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__273__13 _273__a_805_47# _055_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__273__14 _273__a_761_289# _273__a_193_47# _273__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__273__15 VPWR _055_ _273__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__273__16 VGND _273__a_27_47# _273__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__273__17 _273__a_27_47# clknet_2_2__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__273__18 _273__a_27_47# clknet_2_2__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__273__19 VPWR _273__a_1283_21# counter_debounce[19] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__273__20 VPWR _273__a_27_47# _273__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__273__21 _273__a_1283_21# _273__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__273__22 VGND _055_ _273__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__273__23 VPWR net13 _273__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__273__24 _273__a_651_413# _273__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__273__25 _273__a_761_289# _273__a_27_47# _273__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__273__26 VPWR _055_ _273__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__273__27 _273__a_639_47# _273__a_761_289# _273__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _273__13 with the contents of sky130_fd_sc_hd__conb_1

** replacing _274_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__274__0 _274__a_1270_413# _274__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__274__1 VPWR _274__a_543_47# _274__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__274__2 VGND _274__a_543_47# _274__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__274__3 VGND net12 _274__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__274__4 _274__a_1108_47# _274__a_193_47# _274__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__274__5 VGND _274__a_1283_21# counter_debounce[20] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__274__6 _274__a_1217_47# _274__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__274__7 _274__a_448_47# _274__a_27_47# _274__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__274__8 _274__a_448_47# _274__a_193_47# _274__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__274__9 _274__a_543_47# _274__a_193_47# _274__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__274__10 _274__a_1108_47# _274__a_27_47# _274__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__274__11 _274__a_1462_47# _274__a_1108_47# _274__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__274__12 _274__a_543_47# _274__a_27_47# _274__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__274__13 _274__a_805_47# _056_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__274__14 _274__a_761_289# _274__a_193_47# _274__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__274__15 VPWR _056_ _274__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__274__16 VGND _274__a_27_47# _274__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__274__17 _274__a_27_47# clknet_2_2__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__274__18 _274__a_27_47# clknet_2_2__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__274__19 VPWR _274__a_1283_21# counter_debounce[20] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__274__20 VPWR _274__a_27_47# _274__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__274__21 _274__a_1283_21# _274__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__274__22 VGND _056_ _274__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__274__23 VPWR net12 _274__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__274__24 _274__a_651_413# _274__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__274__25 _274__a_761_289# _274__a_27_47# _274__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__274__26 VPWR _056_ _274__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__274__27 _274__a_639_47# _274__a_761_289# _274__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _274__12 with the contents of sky130_fd_sc_hd__conb_1

** replacing _275_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__275__0 _275__a_1270_413# _275__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__275__1 VPWR _275__a_543_47# _275__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__275__2 VGND _275__a_543_47# _275__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__275__3 VGND net11 _275__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__275__4 _275__a_1108_47# _275__a_193_47# _275__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__275__5 VGND _275__a_1283_21# counter_debounce[21] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__275__6 _275__a_1217_47# _275__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__275__7 _275__a_448_47# _275__a_27_47# _275__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__275__8 _275__a_448_47# _275__a_193_47# _275__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__275__9 _275__a_543_47# _275__a_193_47# _275__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__275__10 _275__a_1108_47# _275__a_27_47# _275__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__275__11 _275__a_1462_47# _275__a_1108_47# _275__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__275__12 _275__a_543_47# _275__a_27_47# _275__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__275__13 _275__a_805_47# _057_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__275__14 _275__a_761_289# _275__a_193_47# _275__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__275__15 VPWR _057_ _275__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__275__16 VGND _275__a_27_47# _275__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__275__17 _275__a_27_47# clknet_2_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__275__18 _275__a_27_47# clknet_2_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__275__19 VPWR _275__a_1283_21# counter_debounce[21] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__275__20 VPWR _275__a_27_47# _275__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__275__21 _275__a_1283_21# _275__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__275__22 VGND _057_ _275__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__275__23 VPWR net11 _275__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__275__24 _275__a_651_413# _275__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__275__25 _275__a_761_289# _275__a_27_47# _275__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__275__26 VPWR _057_ _275__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__275__27 _275__a_639_47# _275__a_761_289# _275__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _275__11 with the contents of sky130_fd_sc_hd__conb_1

** replacing _276_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__276__0 _276__a_1270_413# _276__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__276__1 VPWR _276__a_543_47# _276__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__276__2 VGND _276__a_543_47# _276__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__276__3 VGND net10 _276__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__276__4 _276__a_1108_47# _276__a_193_47# _276__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__276__5 VGND _276__a_1283_21# counter_debounce[22] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__276__6 _276__a_1217_47# _276__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__276__7 _276__a_448_47# _276__a_27_47# _276__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__276__8 _276__a_448_47# _276__a_193_47# _276__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__276__9 _276__a_543_47# _276__a_193_47# _276__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__276__10 _276__a_1108_47# _276__a_27_47# _276__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__276__11 _276__a_1462_47# _276__a_1108_47# _276__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__276__12 _276__a_543_47# _276__a_27_47# _276__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__276__13 _276__a_805_47# _058_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__276__14 _276__a_761_289# _276__a_193_47# _276__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__276__15 VPWR _058_ _276__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__276__16 VGND _276__a_27_47# _276__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__276__17 _276__a_27_47# clknet_2_2__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__276__18 _276__a_27_47# clknet_2_2__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__276__19 VPWR _276__a_1283_21# counter_debounce[22] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__276__20 VPWR _276__a_27_47# _276__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__276__21 _276__a_1283_21# _276__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__276__22 VGND _058_ _276__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__276__23 VPWR net10 _276__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__276__24 _276__a_651_413# _276__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__276__25 _276__a_761_289# _276__a_27_47# _276__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__276__26 VPWR _058_ _276__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__276__27 _276__a_639_47# _276__a_761_289# _276__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _276__10 with the contents of sky130_fd_sc_hd__conb_1

** replacing _277_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__277__0 _277__a_1270_413# _277__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__277__1 VPWR _277__a_543_47# _277__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__277__2 VGND _277__a_543_47# _277__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__277__3 VGND net9 _277__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__277__4 _277__a_1108_47# _277__a_193_47# _277__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__277__5 VGND _277__a_1283_21# counter_debounce[23] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__277__6 _277__a_1217_47# _277__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__277__7 _277__a_448_47# _277__a_27_47# _277__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__277__8 _277__a_448_47# _277__a_193_47# _277__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__277__9 _277__a_543_47# _277__a_193_47# _277__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__277__10 _277__a_1108_47# _277__a_27_47# _277__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__277__11 _277__a_1462_47# _277__a_1108_47# _277__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__277__12 _277__a_543_47# _277__a_27_47# _277__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__277__13 _277__a_805_47# _059_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__277__14 _277__a_761_289# _277__a_193_47# _277__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__277__15 VPWR _059_ _277__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__277__16 VGND _277__a_27_47# _277__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__277__17 _277__a_27_47# clknet_2_3__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__277__18 _277__a_27_47# clknet_2_3__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__277__19 VPWR _277__a_1283_21# counter_debounce[23] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__277__20 VPWR _277__a_27_47# _277__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__277__21 _277__a_1283_21# _277__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__277__22 VGND _059_ _277__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__277__23 VPWR net9 _277__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__277__24 _277__a_651_413# _277__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__277__25 _277__a_761_289# _277__a_27_47# _277__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__277__26 VPWR _059_ _277__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__277__27 _277__a_639_47# _277__a_761_289# _277__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _277__9 with the contents of sky130_fd_sc_hd__conb_1

** replacing _278_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__278__0 _278__a_1270_413# _278__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__278__1 VPWR _278__a_543_47# _278__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__278__2 VGND _278__a_543_47# _278__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__278__3 VGND net8 _278__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__278__4 _278__a_1108_47# _278__a_193_47# _278__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__278__5 VGND _278__a_1283_21# counter_debounce[24] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__278__6 _278__a_1217_47# _278__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__278__7 _278__a_448_47# _278__a_27_47# _278__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__278__8 _278__a_448_47# _278__a_193_47# _278__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__278__9 _278__a_543_47# _278__a_193_47# _278__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__278__10 _278__a_1108_47# _278__a_27_47# _278__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__278__11 _278__a_1462_47# _278__a_1108_47# _278__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__278__12 _278__a_543_47# _278__a_27_47# _278__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__278__13 _278__a_805_47# _060_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__278__14 _278__a_761_289# _278__a_193_47# _278__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__278__15 VPWR _060_ _278__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__278__16 VGND _278__a_27_47# _278__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__278__17 _278__a_27_47# clknet_2_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__278__18 _278__a_27_47# clknet_2_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__278__19 VPWR _278__a_1283_21# counter_debounce[24] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__278__20 VPWR _278__a_27_47# _278__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__278__21 _278__a_1283_21# _278__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__278__22 VGND _060_ _278__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__278__23 VPWR net8 _278__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__278__24 _278__a_651_413# _278__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__278__25 _278__a_761_289# _278__a_27_47# _278__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__278__26 VPWR _060_ _278__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__278__27 _278__a_639_47# _278__a_761_289# _278__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _278__8 with the contents of sky130_fd_sc_hd__conb_1

** replacing _279_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__279__0 _279__a_1270_413# _279__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__279__1 VPWR _279__a_543_47# _279__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__279__2 VGND _279__a_543_47# _279__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__279__3 VGND net7 _279__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__279__4 _279__a_1108_47# _279__a_193_47# _279__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__279__5 VGND _279__a_1283_21# counter_debounce[25] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__279__6 _279__a_1217_47# _279__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__279__7 _279__a_448_47# _279__a_27_47# _279__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__279__8 _279__a_448_47# _279__a_193_47# _279__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__279__9 _279__a_543_47# _279__a_193_47# _279__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__279__10 _279__a_1108_47# _279__a_27_47# _279__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__279__11 _279__a_1462_47# _279__a_1108_47# _279__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__279__12 _279__a_543_47# _279__a_27_47# _279__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__279__13 _279__a_805_47# _061_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__279__14 _279__a_761_289# _279__a_193_47# _279__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__279__15 VPWR _061_ _279__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__279__16 VGND _279__a_27_47# _279__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__279__17 _279__a_27_47# clknet_2_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__279__18 _279__a_27_47# clknet_2_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__279__19 VPWR _279__a_1283_21# counter_debounce[25] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__279__20 VPWR _279__a_27_47# _279__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__279__21 _279__a_1283_21# _279__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__279__22 VGND _061_ _279__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__279__23 VPWR net7 _279__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__279__24 _279__a_651_413# _279__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__279__25 _279__a_761_289# _279__a_27_47# _279__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__279__26 VPWR _061_ _279__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__279__27 _279__a_639_47# _279__a_761_289# _279__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _279__7 with the contents of sky130_fd_sc_hd__conb_1

** replacing _280_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__280__0 _280__a_1270_413# _280__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__280__1 VPWR _280__a_543_47# _280__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__280__2 VGND _280__a_543_47# _280__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__280__3 VGND net6 _280__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__280__4 _280__a_1108_47# _280__a_193_47# _280__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__280__5 VGND _280__a_1283_21# counter_debounce[26] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__280__6 _280__a_1217_47# _280__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__280__7 _280__a_448_47# _280__a_27_47# _280__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__280__8 _280__a_448_47# _280__a_193_47# _280__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__280__9 _280__a_543_47# _280__a_193_47# _280__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__280__10 _280__a_1108_47# _280__a_27_47# _280__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__280__11 _280__a_1462_47# _280__a_1108_47# _280__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__280__12 _280__a_543_47# _280__a_27_47# _280__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__280__13 _280__a_805_47# _062_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__280__14 _280__a_761_289# _280__a_193_47# _280__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__280__15 VPWR _062_ _280__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__280__16 VGND _280__a_27_47# _280__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__280__17 _280__a_27_47# clknet_2_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__280__18 _280__a_27_47# clknet_2_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__280__19 VPWR _280__a_1283_21# counter_debounce[26] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__280__20 VPWR _280__a_27_47# _280__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__280__21 _280__a_1283_21# _280__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__280__22 VGND _062_ _280__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__280__23 VPWR net6 _280__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__280__24 _280__a_651_413# _280__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__280__25 _280__a_761_289# _280__a_27_47# _280__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__280__26 VPWR _062_ _280__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__280__27 _280__a_639_47# _280__a_761_289# _280__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _280__6 with the contents of sky130_fd_sc_hd__conb_1

** replacing _281_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__281__0 _281__a_1270_413# _281__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__281__1 VPWR _281__a_543_47# _281__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__281__2 VGND _281__a_543_47# _281__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__281__3 VGND net5 _281__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__281__4 _281__a_1108_47# _281__a_193_47# _281__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__281__5 VGND _281__a_1283_21# counter_debounce[27] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__281__6 _281__a_1217_47# _281__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__281__7 _281__a_448_47# _281__a_27_47# _281__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__281__8 _281__a_448_47# _281__a_193_47# _281__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__281__9 _281__a_543_47# _281__a_193_47# _281__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__281__10 _281__a_1108_47# _281__a_27_47# _281__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__281__11 _281__a_1462_47# _281__a_1108_47# _281__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__281__12 _281__a_543_47# _281__a_27_47# _281__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__281__13 _281__a_805_47# _063_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__281__14 _281__a_761_289# _281__a_193_47# _281__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__281__15 VPWR _063_ _281__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__281__16 VGND _281__a_27_47# _281__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__281__17 _281__a_27_47# clknet_2_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__281__18 _281__a_27_47# clknet_2_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__281__19 VPWR _281__a_1283_21# counter_debounce[27] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__281__20 VPWR _281__a_27_47# _281__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__281__21 _281__a_1283_21# _281__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__281__22 VGND _063_ _281__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__281__23 VPWR net5 _281__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__281__24 _281__a_651_413# _281__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__281__25 _281__a_761_289# _281__a_27_47# _281__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__281__26 VPWR _063_ _281__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__281__27 _281__a_639_47# _281__a_761_289# _281__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _281__5 with the contents of sky130_fd_sc_hd__conb_1

** replacing _282_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__282__0 _282__a_1270_413# _282__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__282__1 VPWR _282__a_543_47# _282__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__282__2 VGND _282__a_543_47# _282__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__282__3 VGND _076_ _282__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__282__4 _282__a_1108_47# _282__a_193_47# _282__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__282__5 VGND _282__a_1283_21# tmp1 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__282__6 _282__a_1217_47# _282__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__282__7 _282__a_448_47# _282__a_27_47# _282__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__282__8 _282__a_448_47# _282__a_193_47# _282__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__282__9 _282__a_543_47# _282__a_193_47# _282__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__282__10 _282__a_1108_47# _282__a_27_47# _282__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__282__11 _282__a_1462_47# _282__a_1108_47# _282__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__282__12 _282__a_543_47# _282__a_27_47# _282__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__282__13 _282__a_805_47# _064_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__282__14 _282__a_761_289# _282__a_193_47# _282__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__282__15 VPWR _064_ _282__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__282__16 VGND _282__a_27_47# _282__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__282__17 _282__a_27_47# clknet_2_2__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__282__18 _282__a_27_47# clknet_2_2__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__282__19 VPWR _282__a_1283_21# tmp1 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__282__20 VPWR _282__a_27_47# _282__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__282__21 _282__a_1283_21# _282__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__282__22 VGND _064_ _282__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__282__23 VPWR _076_ _282__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__282__24 _282__a_651_413# _282__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__282__25 _282__a_761_289# _282__a_27_47# _282__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__282__26 VPWR _064_ _282__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__282__27 _282__a_639_47# _282__a_761_289# _282__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _283_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__283__0 _283__a_1270_413# _283__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__283__1 VPWR _283__a_543_47# _283__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__283__2 VGND _283__a_543_47# _283__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__283__3 VGND _077_ _283__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__283__4 _283__a_1108_47# _283__a_193_47# _283__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__283__5 VGND _283__a_1283_21# tmp2 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__283__6 _283__a_1217_47# _283__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__283__7 _283__a_448_47# _283__a_27_47# _283__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__283__8 _283__a_448_47# _283__a_193_47# _283__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__283__9 _283__a_543_47# _283__a_193_47# _283__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__283__10 _283__a_1108_47# _283__a_27_47# _283__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__283__11 _283__a_1462_47# _283__a_1108_47# _283__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__283__12 _283__a_543_47# _283__a_27_47# _283__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__283__13 _283__a_805_47# _065_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__283__14 _283__a_761_289# _283__a_193_47# _283__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__283__15 VPWR _065_ _283__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__283__16 VGND _283__a_27_47# _283__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__283__17 _283__a_27_47# clknet_2_3__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__283__18 _283__a_27_47# clknet_2_3__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__283__19 VPWR _283__a_1283_21# tmp2 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__283__20 VPWR _283__a_27_47# _283__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__283__21 _283__a_1283_21# _283__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__283__22 VGND _065_ _283__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__283__23 VPWR _077_ _283__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__283__24 _283__a_651_413# _283__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__283__25 _283__a_761_289# _283__a_27_47# _283__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__283__26 VPWR _065_ _283__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__283__27 _283__a_639_47# _283__a_761_289# _283__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _284_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__284__0 _284__a_1270_413# _284__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__284__1 VPWR _284__a_543_47# _284__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__284__2 VGND _284__a_543_47# _284__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__284__3 VGND _078_ _284__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__284__4 _284__a_1108_47# _284__a_193_47# _284__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__284__5 VGND _284__a_1283_21# tmp3 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__284__6 _284__a_1217_47# _284__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__284__7 _284__a_448_47# _284__a_27_47# _284__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__284__8 _284__a_448_47# _284__a_193_47# _284__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__284__9 _284__a_543_47# _284__a_193_47# _284__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__284__10 _284__a_1108_47# _284__a_27_47# _284__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__284__11 _284__a_1462_47# _284__a_1108_47# _284__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__284__12 _284__a_543_47# _284__a_27_47# _284__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__284__13 _284__a_805_47# _066_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__284__14 _284__a_761_289# _284__a_193_47# _284__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__284__15 VPWR _066_ _284__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__284__16 VGND _284__a_27_47# _284__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__284__17 _284__a_27_47# clknet_2_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__284__18 _284__a_27_47# clknet_2_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__284__19 VPWR _284__a_1283_21# tmp3 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__284__20 VPWR _284__a_27_47# _284__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__284__21 _284__a_1283_21# _284__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__284__22 VGND _066_ _284__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__284__23 VPWR _078_ _284__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__284__24 _284__a_651_413# _284__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__284__25 _284__a_761_289# _284__a_27_47# _284__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__284__26 VPWR _066_ _284__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__284__27 _284__a_639_47# _284__a_761_289# _284__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _285_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__285__0 _285__a_1270_413# _285__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__285__1 VPWR _285__a_543_47# _285__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__285__2 VGND _285__a_543_47# _285__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__285__3 VGND _000_ _285__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__285__4 _285__a_1108_47# _285__a_193_47# _285__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__285__5 VGND _285__a_1283_21# counter_PWM[0] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__285__6 _285__a_1217_47# _285__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__285__7 _285__a_448_47# _285__a_27_47# _285__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__285__8 _285__a_448_47# _285__a_193_47# _285__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__285__9 _285__a_543_47# _285__a_193_47# _285__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__285__10 _285__a_1108_47# _285__a_27_47# _285__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__285__11 _285__a_1462_47# _285__a_1108_47# _285__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__285__12 _285__a_543_47# _285__a_27_47# _285__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__285__13 _285__a_805_47# _067_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__285__14 _285__a_761_289# _285__a_193_47# _285__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__285__15 VPWR _067_ _285__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__285__16 VGND _285__a_27_47# _285__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__285__17 _285__a_27_47# clknet_2_3__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__285__18 _285__a_27_47# clknet_2_3__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__285__19 VPWR _285__a_1283_21# counter_PWM[0] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__285__20 VPWR _285__a_27_47# _285__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__285__21 _285__a_1283_21# _285__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__285__22 VGND _067_ _285__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__285__23 VPWR _000_ _285__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__285__24 _285__a_651_413# _285__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__285__25 _285__a_761_289# _285__a_27_47# _285__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__285__26 VPWR _067_ _285__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__285__27 _285__a_639_47# _285__a_761_289# _285__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _286_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__286__0 _286__a_1270_413# _286__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__286__1 VPWR _286__a_543_47# _286__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__286__2 VGND _286__a_543_47# _286__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__286__3 VGND _001_ _286__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__286__4 _286__a_1108_47# _286__a_193_47# _286__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__286__5 VGND _286__a_1283_21# counter_PWM[1] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__286__6 _286__a_1217_47# _286__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__286__7 _286__a_448_47# _286__a_27_47# _286__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__286__8 _286__a_448_47# _286__a_193_47# _286__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__286__9 _286__a_543_47# _286__a_193_47# _286__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__286__10 _286__a_1108_47# _286__a_27_47# _286__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__286__11 _286__a_1462_47# _286__a_1108_47# _286__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__286__12 _286__a_543_47# _286__a_27_47# _286__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__286__13 _286__a_805_47# _068_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__286__14 _286__a_761_289# _286__a_193_47# _286__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__286__15 VPWR _068_ _286__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__286__16 VGND _286__a_27_47# _286__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__286__17 _286__a_27_47# clknet_2_2__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__286__18 _286__a_27_47# clknet_2_2__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__286__19 VPWR _286__a_1283_21# counter_PWM[1] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__286__20 VPWR _286__a_27_47# _286__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__286__21 _286__a_1283_21# _286__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__286__22 VGND _068_ _286__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__286__23 VPWR _001_ _286__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__286__24 _286__a_651_413# _286__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__286__25 _286__a_761_289# _286__a_27_47# _286__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__286__26 VPWR _068_ _286__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__286__27 _286__a_639_47# _286__a_761_289# _286__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _287_ with the contents of sky130_fd_sc_hd__dfrtp_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__287__0 _287__a_1270_413# _287__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Q w=1]]', 'g: [connection X1/g =>[signal: a_1283_21# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__287__1 counter_PWM[2] _287__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VPWR w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__287__2 VPWR _287__a_543_47# _287__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: a_543_47# w=1]]', 's: [connection X3/s =>[signal: a_761_289# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__287__3 VGND _287__a_543_47# _287__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: D w=1]]', 's: [connection X4/s =>[signal: a_448_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__287__4 VGND _002_ _287__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_1108_47# w=1]]', 'g: [connection X5/g =>[signal: a_193_47# w=1]]', 's: [connection X5/s =>[signal: a_1270_413# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__287__5 _287__a_1108_47# _287__a_193_47# _287__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: Q w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__287__6 VGND _287__a_1283_21# counter_PWM[2] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_1217_47# w=1]]', 'g: [connection X7/g =>[signal: a_1283_21# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__287__7 _287__a_1217_47# _287__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_27_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__287__8 _287__a_448_47# _287__a_27_47# _287__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_448_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_543_47# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__287__9 _287__a_448_47# _287__a_193_47# _287__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_543_47# w=1]]', 'g: [connection X10/g =>[signal: a_193_47# w=1]]', 's: [connection X10/s =>[signal: a_639_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__287__10 _287__a_543_47# _287__a_193_47# _287__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1108_47# w=1]]', 'g: [connection X11/g =>[signal: a_27_47# w=1]]', 's: [connection X11/s =>[signal: a_1217_47# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__287__11 _287__a_1108_47# _287__a_27_47# _287__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_1462_47# w=1]]', 'g: [connection X12/g =>[signal: a_1108_47# w=1]]', 's: [connection X12/s =>[signal: a_1283_21# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__287__12 _287__a_1462_47# _287__a_1108_47# _287__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_543_47# w=1]]', 'g: [connection X13/g =>[signal: a_27_47# w=1]]', 's: [connection X13/s =>[signal: a_651_413# w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X__287__13 _287__a_543_47# _287__a_27_47# _287__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_805_47# w=1]]', 'g: [connection X14/g =>[signal: RESET_B w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__287__14 _287__a_805_47# _069_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: Q w=1]]', 'g: [connection X15/g =>[signal: a_1283_21# w=1]]', 's: [connection X15/s =>[signal: VPWR w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__287__15 counter_PWM[2] _287__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: a_761_289# w=1]]', 'g: [connection X16/g =>[signal: a_193_47# w=1]]', 's: [connection X16/s =>[signal: a_1108_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__287__16 _287__a_761_289# _287__a_193_47# _287__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X17 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: VPWR w=1]]', 'g: [connection X17/g =>[signal: RESET_B w=1]]', 's: [connection X17/s =>[signal: a_651_413# w=1]]', 'b: [connection X17/b =>[signal: VPB w=1]]']]
X__287__17 VPWR _069_ _287__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_27_47# w=1]]', 's: [connection X18/s =>[signal: a_193_47# w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__287__18 VGND _287__a_27_47# _287__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VGND w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X__287__19 _287__a_27_47# clknet_2_0__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: a_27_47# w=1]]', 'g: [connection X20/g =>[signal: CLK w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__287__20 _287__a_27_47# clknet_2_0__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VPWR w=1]]', 'g: [connection X21/g =>[signal: a_1283_21# w=1]]', 's: [connection X21/s =>[signal: Q w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__287__21 VPWR _287__a_1283_21# counter_PWM[2] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VPWR w=1]]', 'g: [connection X22/g =>[signal: a_27_47# w=1]]', 's: [connection X22/s =>[signal: a_193_47# w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__287__22 VPWR _287__a_27_47# _287__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: a_1283_21# w=1]]', 'g: [connection X23/g =>[signal: a_1108_47# w=1]]', 's: [connection X23/s =>[signal: VPWR w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__287__23 _287__a_1283_21# _287__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VGND w=1]]', 'g: [connection X24/g =>[signal: RESET_B w=1]]', 's: [connection X24/s =>[signal: a_1462_47# w=1]]', 'b: [connection X24/b =>[signal: VNB w=1]]']]
X__287__24 VGND _069_ _287__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VPWR w=1]]', 'g: [connection X25/g =>[signal: D w=1]]', 's: [connection X25/s =>[signal: a_448_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__287__25 VPWR _002_ _287__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: a_651_413# w=1]]', 'g: [connection X26/g =>[signal: a_761_289# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__287__26 _287__a_651_413# _287__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_761_289# w=1]]', 'g: [connection X27/g =>[signal: a_27_47# w=1]]', 's: [connection X27/s =>[signal: a_1108_47# w=1]]', 'b: [connection X27/b =>[signal: VPB w=1]]']]
X__287__27 _287__a_761_289# _287__a_27_47# _287__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: RESET_B w=1]]', 's: [connection X28/s =>[signal: a_1283_21# w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X__287__28 VPWR _069_ _287__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: a_639_47# w=1]]', 'g: [connection X29/g =>[signal: a_761_289# w=1]]', 's: [connection X29/s =>[signal: a_805_47# w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X__287__29 _287__a_639_47# _287__a_761_289# _287__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _288_ with the contents of sky130_fd_sc_hd__dfrtp_2
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__288__0 _288__a_1270_413# _288__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: Q w=1]]', 'g: [connection X1/g =>[signal: a_1283_21# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X__288__1 counter_PWM[3] _288__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X2 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VPWR w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VPB w=1]]']]
X__288__2 VPWR _288__a_543_47# _288__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: a_543_47# w=1]]', 's: [connection X3/s =>[signal: a_761_289# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__288__3 VGND _288__a_543_47# _288__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X4 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VGND w=1]]', 'g: [connection X4/g =>[signal: D w=1]]', 's: [connection X4/s =>[signal: a_448_47# w=1]]', 'b: [connection X4/b =>[signal: VNB w=1]]']]
X__288__4 VGND _003_ _288__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_1108_47# w=1]]', 'g: [connection X5/g =>[signal: a_193_47# w=1]]', 's: [connection X5/s =>[signal: a_1270_413# w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X__288__5 _288__a_1108_47# _288__a_193_47# _288__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: VGND w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: Q w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__288__6 VGND _288__a_1283_21# counter_PWM[3] VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_1217_47# w=1]]', 'g: [connection X7/g =>[signal: a_1283_21# w=1]]', 's: [connection X7/s =>[signal: VGND w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__288__7 _288__a_1217_47# _288__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_27_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X__288__8 _288__a_448_47# _288__a_27_47# _288__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X9 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_448_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_543_47# w=1]]', 'b: [connection X9/b =>[signal: VPB w=1]]']]
X__288__9 _288__a_448_47# _288__a_193_47# _288__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_543_47# w=1]]', 'g: [connection X10/g =>[signal: a_193_47# w=1]]', 's: [connection X10/s =>[signal: a_639_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__288__10 _288__a_543_47# _288__a_193_47# _288__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1108_47# w=1]]', 'g: [connection X11/g =>[signal: a_27_47# w=1]]', 's: [connection X11/s =>[signal: a_1217_47# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__288__11 _288__a_1108_47# _288__a_27_47# _288__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X12 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_1462_47# w=1]]', 'g: [connection X12/g =>[signal: a_1108_47# w=1]]', 's: [connection X12/s =>[signal: a_1283_21# w=1]]', 'b: [connection X12/b =>[signal: VNB w=1]]']]
X__288__12 _288__a_1462_47# _288__a_1108_47# _288__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_543_47# w=1]]', 'g: [connection X13/g =>[signal: a_27_47# w=1]]', 's: [connection X13/s =>[signal: a_651_413# w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X__288__13 _288__a_543_47# _288__a_27_47# _288__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_805_47# w=1]]', 'g: [connection X14/g =>[signal: RESET_B w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__288__14 _288__a_805_47# _070_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: Q w=1]]', 'g: [connection X15/g =>[signal: a_1283_21# w=1]]', 's: [connection X15/s =>[signal: VPWR w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__288__15 counter_PWM[3] _288__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: a_761_289# w=1]]', 'g: [connection X16/g =>[signal: a_193_47# w=1]]', 's: [connection X16/s =>[signal: a_1108_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__288__16 _288__a_761_289# _288__a_193_47# _288__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X17 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: VPWR w=1]]', 'g: [connection X17/g =>[signal: RESET_B w=1]]', 's: [connection X17/s =>[signal: a_651_413# w=1]]', 'b: [connection X17/b =>[signal: VPB w=1]]']]
X__288__17 VPWR _070_ _288__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_27_47# w=1]]', 's: [connection X18/s =>[signal: a_193_47# w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X__288__18 VGND _288__a_27_47# _288__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: a_27_47# w=1]]', 'g: [connection X19/g =>[signal: CLK w=1]]', 's: [connection X19/s =>[signal: VGND w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X__288__19 _288__a_27_47# clknet_2_3__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: a_27_47# w=1]]', 'g: [connection X20/g =>[signal: CLK w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__288__20 _288__a_27_47# clknet_2_3__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: VPWR w=1]]', 'g: [connection X21/g =>[signal: a_1283_21# w=1]]', 's: [connection X21/s =>[signal: Q w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__288__21 VPWR _288__a_1283_21# counter_PWM[3] VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VPWR w=1]]', 'g: [connection X22/g =>[signal: a_27_47# w=1]]', 's: [connection X22/s =>[signal: a_193_47# w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X__288__22 VPWR _288__a_27_47# _288__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: a_1283_21# w=1]]', 'g: [connection X23/g =>[signal: a_1108_47# w=1]]', 's: [connection X23/s =>[signal: VPWR w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__288__23 _288__a_1283_21# _288__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VGND w=1]]', 'g: [connection X24/g =>[signal: RESET_B w=1]]', 's: [connection X24/s =>[signal: a_1462_47# w=1]]', 'b: [connection X24/b =>[signal: VNB w=1]]']]
X__288__24 VGND _070_ _288__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VPWR w=1]]', 'g: [connection X25/g =>[signal: D w=1]]', 's: [connection X25/s =>[signal: a_448_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__288__25 VPWR _003_ _288__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: a_651_413# w=1]]', 'g: [connection X26/g =>[signal: a_761_289# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__288__26 _288__a_651_413# _288__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_761_289# w=1]]', 'g: [connection X27/g =>[signal: a_27_47# w=1]]', 's: [connection X27/s =>[signal: a_1108_47# w=1]]', 'b: [connection X27/b =>[signal: VPB w=1]]']]
X__288__27 _288__a_761_289# _288__a_27_47# _288__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: RESET_B w=1]]', 's: [connection X28/s =>[signal: a_1283_21# w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X__288__28 VPWR _070_ _288__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: a_639_47# w=1]]', 'g: [connection X29/g =>[signal: a_761_289# w=1]]', 's: [connection X29/s =>[signal: a_805_47# w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X__288__29 _288__a_639_47# _288__a_761_289# _288__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing _289_ with the contents of sky130_fd_sc_hd__dfrtp_1
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: a_1270_413# w=1]]', 'g: [connection X0/g =>[signal: a_1283_21# w=1]]', 's: [connection X0/s =>[signal: VPWR w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X__289__0 _289__a_1270_413# _289__a_1283_21# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '840000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: VPWR w=1]]', 'g: [connection X1/g =>[signal: a_543_47# w=1]]', 's: [connection X1/s =>[signal: a_761_289# w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X__289__1 VPWR _289__a_543_47# _289__a_761_289# VPWR sky130_fd_pr__pfet_01v8_hvt W=840000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_543_47# w=1]]', 's: [connection X2/s =>[signal: a_761_289# w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X__289__2 VGND _289__a_543_47# _289__a_761_289# VGND sky130_fd_pr__nfet_01v8 W=640000u L=150000u
** [instance X3 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VGND w=1]]', 'g: [connection X3/g =>[signal: D w=1]]', 's: [connection X3/s =>[signal: a_448_47# w=1]]', 'b: [connection X3/b =>[signal: VNB w=1]]']]
X__289__3 VGND _079_ _289__a_448_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: a_1108_47# w=1]]', 'g: [connection X4/g =>[signal: a_193_47# w=1]]', 's: [connection X4/s =>[signal: a_1270_413# w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X__289__4 _289__a_1108_47# _289__a_193_47# _289__a_1270_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: VGND w=1]]', 'g: [connection X5/g =>[signal: a_1283_21# w=1]]', 's: [connection X5/s =>[signal: Q w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X__289__5 VGND _289__a_1283_21# tmp4 VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_1217_47# w=1]]', 'g: [connection X6/g =>[signal: a_1283_21# w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X__289__6 _289__a_1217_47# _289__a_1283_21# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: a_448_47# w=1]]', 'g: [connection X7/g =>[signal: a_27_47# w=1]]', 's: [connection X7/s =>[signal: a_543_47# w=1]]', 'b: [connection X7/b =>[signal: VNB w=1]]']]
X__289__7 _289__a_448_47# _289__a_27_47# _289__a_543_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X8 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: a_448_47# w=1]]', 'g: [connection X8/g =>[signal: a_193_47# w=1]]', 's: [connection X8/s =>[signal: a_543_47# w=1]]', 'b: [connection X8/b =>[signal: VPB w=1]]']]
X__289__8 _289__a_448_47# _289__a_193_47# _289__a_543_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: a_543_47# w=1]]', 'g: [connection X9/g =>[signal: a_193_47# w=1]]', 's: [connection X9/s =>[signal: a_639_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X__289__9 _289__a_543_47# _289__a_193_47# _289__a_639_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: a_1108_47# w=1]]', 'g: [connection X10/g =>[signal: a_27_47# w=1]]', 's: [connection X10/s =>[signal: a_1217_47# w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X__289__10 _289__a_1108_47# _289__a_27_47# _289__a_1217_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: a_1462_47# w=1]]', 'g: [connection X11/g =>[signal: a_1108_47# w=1]]', 's: [connection X11/s =>[signal: a_1283_21# w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X__289__11 _289__a_1462_47# _289__a_1108_47# _289__a_1283_21# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_543_47# w=1]]', 'g: [connection X12/g =>[signal: a_27_47# w=1]]', 's: [connection X12/s =>[signal: a_651_413# w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X__289__12 _289__a_543_47# _289__a_27_47# _289__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X13 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: a_805_47# w=1]]', 'g: [connection X13/g =>[signal: RESET_B w=1]]', 's: [connection X13/s =>[signal: VGND w=1]]', 'b: [connection X13/b =>[signal: VNB w=1]]']]
X__289__13 _289__a_805_47# _071_ VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '360000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: a_761_289# w=1]]', 'g: [connection X14/g =>[signal: a_193_47# w=1]]', 's: [connection X14/s =>[signal: a_1108_47# w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X__289__14 _289__a_761_289# _289__a_193_47# _289__a_1108_47# VGND sky130_fd_pr__nfet_01v8 W=360000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: RESET_B w=1]]', 's: [connection X15/s =>[signal: a_651_413# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X__289__15 VPWR _071_ _289__a_651_413# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_27_47# w=1]]', 's: [connection X16/s =>[signal: a_193_47# w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X__289__16 VGND _289__a_27_47# _289__a_193_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: a_27_47# w=1]]', 'g: [connection X17/g =>[signal: CLK w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X__289__17 _289__a_27_47# clknet_2_1__leaf_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: a_27_47# w=1]]', 'g: [connection X18/g =>[signal: CLK w=1]]', 's: [connection X18/s =>[signal: VPWR w=1]]', 'b: [connection X18/b =>[signal: VPB w=1]]']]
X__289__18 _289__a_27_47# clknet_2_1__leaf_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X19 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VPWR w=1]]', 'g: [connection X19/g =>[signal: a_1283_21# w=1]]', 's: [connection X19/s =>[signal: Q w=1]]', 'b: [connection X19/b =>[signal: VPB w=1]]']]
X__289__19 VPWR _289__a_1283_21# tmp4 VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: VPWR w=1]]', 'g: [connection X20/g =>[signal: a_27_47# w=1]]', 's: [connection X20/s =>[signal: a_193_47# w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X__289__20 VPWR _289__a_27_47# _289__a_193_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: a_1283_21# w=1]]', 'g: [connection X21/g =>[signal: a_1108_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X__289__21 _289__a_1283_21# _289__a_1108_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X22 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: VGND w=1]]', 'g: [connection X22/g =>[signal: RESET_B w=1]]', 's: [connection X22/s =>[signal: a_1462_47# w=1]]', 'b: [connection X22/b =>[signal: VNB w=1]]']]
X__289__22 VGND _071_ _289__a_1462_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: D w=1]]', 's: [connection X23/s =>[signal: a_448_47# w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X__289__23 VPWR _079_ _289__a_448_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: a_651_413# w=1]]', 'g: [connection X24/g =>[signal: a_761_289# w=1]]', 's: [connection X24/s =>[signal: VPWR w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X__289__24 _289__a_651_413# _289__a_761_289# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X25 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: a_761_289# w=1]]', 'g: [connection X25/g =>[signal: a_27_47# w=1]]', 's: [connection X25/s =>[signal: a_1108_47# w=1]]', 'b: [connection X25/b =>[signal: VPB w=1]]']]
X__289__25 _289__a_761_289# _289__a_27_47# _289__a_1108_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: VPWR w=1]]', 'g: [connection X26/g =>[signal: RESET_B w=1]]', 's: [connection X26/s =>[signal: a_1283_21# w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X__289__26 VPWR _071_ _289__a_1283_21# VPWR sky130_fd_pr__pfet_01v8_hvt W=420000u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: a_639_47# w=1]]', 'g: [connection X27/g =>[signal: a_761_289# w=1]]', 's: [connection X27/s =>[signal: a_805_47# w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X__289__27 _289__a_639_47# _289__a_761_289# _289__a_805_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing clkbuf_0_clk with the contents of sky130_fd_sc_hd__clkbuf_16
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_110_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_0 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_110_47# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_1 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_110_47# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_2 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_110_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_3 clkbuf_0_clk_a_110_47# clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_110_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_4 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: X w=1]]', 'g: [connection X5/g =>[signal: a_110_47# w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_5 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_110_47# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_6 clkbuf_0_clk_a_110_47# clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: a_110_47# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_7 VPWR clk clkbuf_0_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: a_110_47# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_8 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_110_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_9 VGND clk clkbuf_0_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_110_47# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_10 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: X w=1]]', 'g: [connection X11/g =>[signal: a_110_47# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_11 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_110_47# w=1]]', 'g: [connection X12/g =>[signal: A w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_12 clkbuf_0_clk_a_110_47# clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VPWR w=1]]', 'g: [connection X13/g =>[signal: a_110_47# w=1]]', 's: [connection X13/s =>[signal: X w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_13 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: X w=1]]', 'g: [connection X14/g =>[signal: a_110_47# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_14 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: A w=1]]', 's: [connection X15/s =>[signal: a_110_47# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_15 VPWR clk clkbuf_0_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_110_47# w=1]]', 's: [connection X16/s =>[signal: X w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_16 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: X w=1]]', 'g: [connection X17/g =>[signal: a_110_47# w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_17 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_110_47# w=1]]', 's: [connection X18/s =>[signal: X w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_18 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_110_47# w=1]]', 's: [connection X19/s =>[signal: X w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_19 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: X w=1]]', 'g: [connection X20/g =>[signal: a_110_47# w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_20 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: X w=1]]', 'g: [connection X21/g =>[signal: a_110_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_21 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: X w=1]]', 'g: [connection X22/g =>[signal: a_110_47# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_22 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: a_110_47# w=1]]', 's: [connection X23/s =>[signal: X w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_23 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VPWR w=1]]', 'g: [connection X24/g =>[signal: a_110_47# w=1]]', 's: [connection X24/s =>[signal: X w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_24 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_110_47# w=1]]', 's: [connection X25/s =>[signal: X w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_25 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: X w=1]]', 'g: [connection X26/g =>[signal: a_110_47# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_26 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: X w=1]]', 'g: [connection X27/g =>[signal: a_110_47# w=1]]', 's: [connection X27/s =>[signal: VGND w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_27 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_110_47# w=1]]', 's: [connection X28/s =>[signal: X w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_28 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: a_110_47# w=1]]', 's: [connection X29/s =>[signal: X w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_29 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: X w=1]]', 'g: [connection X30/g =>[signal: a_110_47# w=1]]', 's: [connection X30/s =>[signal: VGND w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_30 clknet_0_clk clkbuf_0_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: X w=1]]', 'g: [connection X31/g =>[signal: a_110_47# w=1]]', 's: [connection X31/s =>[signal: VPWR w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_31 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X32 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X32/d =>[signal: X w=1]]', 'g: [connection X32/g =>[signal: a_110_47# w=1]]', 's: [connection X32/s =>[signal: VPWR w=1]]', 'b: [connection X32/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_32 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X33 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X33/d =>[signal: X w=1]]', 'g: [connection X33/g =>[signal: a_110_47# w=1]]', 's: [connection X33/s =>[signal: VPWR w=1]]', 'b: [connection X33/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_33 clknet_0_clk clkbuf_0_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X34 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X34/d =>[signal: a_110_47# w=1]]', 'g: [connection X34/g =>[signal: A w=1]]', 's: [connection X34/s =>[signal: VGND w=1]]', 'b: [connection X34/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_34 clkbuf_0_clk_a_110_47# clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X35 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X35/d =>[signal: VPWR w=1]]', 'g: [connection X35/g =>[signal: a_110_47# w=1]]', 's: [connection X35/s =>[signal: X w=1]]', 'b: [connection X35/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_35 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X36 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X36/d =>[signal: VGND w=1]]', 'g: [connection X36/g =>[signal: A w=1]]', 's: [connection X36/s =>[signal: a_110_47# w=1]]', 'b: [connection X36/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_36 VGND clk clkbuf_0_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X37 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X37/d =>[signal: VPWR w=1]]', 'g: [connection X37/g =>[signal: a_110_47# w=1]]', 's: [connection X37/s =>[signal: X w=1]]', 'b: [connection X37/b =>[signal: VPB w=1]]']]
X_clkbuf_0_clk_37 VPWR clkbuf_0_clk_a_110_47# clknet_0_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X38 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X38/d =>[signal: VGND w=1]]', 'g: [connection X38/g =>[signal: a_110_47# w=1]]', 's: [connection X38/s =>[signal: X w=1]]', 'b: [connection X38/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_38 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X39 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X39/d =>[signal: VGND w=1]]', 'g: [connection X39/g =>[signal: a_110_47# w=1]]', 's: [connection X39/s =>[signal: X w=1]]', 'b: [connection X39/b =>[signal: VNB w=1]]']]
X_clkbuf_0_clk_39 VGND clkbuf_0_clk_a_110_47# clknet_0_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing clkbuf_2_0__f_clk with the contents of sky130_fd_sc_hd__clkbuf_16
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_110_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_0 VPWR clkbuf_2_0__f_clk_a_110_47# clknet_2_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_110_47# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_1 clknet_2_0__leaf_clk clkbuf_2_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_110_47# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_2 clknet_2_0__leaf_clk clkbuf_2_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_110_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_3 clkbuf_2_0__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_110_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_4 VPWR clkbuf_2_0__f_clk_a_110_47# clknet_2_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: X w=1]]', 'g: [connection X5/g =>[signal: a_110_47# w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_5 clknet_2_0__leaf_clk clkbuf_2_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_110_47# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_6 clkbuf_2_0__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: a_110_47# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_7 VPWR clknet_0_clk clkbuf_2_0__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: a_110_47# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_8 VGND clkbuf_2_0__f_clk_a_110_47# clknet_2_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_110_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_9 VGND clknet_0_clk clkbuf_2_0__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_110_47# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_10 clknet_2_0__leaf_clk clkbuf_2_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: X w=1]]', 'g: [connection X11/g =>[signal: a_110_47# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_11 clknet_2_0__leaf_clk clkbuf_2_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_110_47# w=1]]', 'g: [connection X12/g =>[signal: A w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_12 clkbuf_2_0__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VPWR w=1]]', 'g: [connection X13/g =>[signal: a_110_47# w=1]]', 's: [connection X13/s =>[signal: X w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_13 VPWR clkbuf_2_0__f_clk_a_110_47# clknet_2_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: X w=1]]', 'g: [connection X14/g =>[signal: a_110_47# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_14 clknet_2_0__leaf_clk clkbuf_2_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: A w=1]]', 's: [connection X15/s =>[signal: a_110_47# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_15 VPWR clknet_0_clk clkbuf_2_0__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_110_47# w=1]]', 's: [connection X16/s =>[signal: X w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_16 VGND clkbuf_2_0__f_clk_a_110_47# clknet_2_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: X w=1]]', 'g: [connection X17/g =>[signal: a_110_47# w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_17 clknet_2_0__leaf_clk clkbuf_2_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_110_47# w=1]]', 's: [connection X18/s =>[signal: X w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_18 VGND clkbuf_2_0__f_clk_a_110_47# clknet_2_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_110_47# w=1]]', 's: [connection X19/s =>[signal: X w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_19 VGND clkbuf_2_0__f_clk_a_110_47# clknet_2_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: X w=1]]', 'g: [connection X20/g =>[signal: a_110_47# w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_20 clknet_2_0__leaf_clk clkbuf_2_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: X w=1]]', 'g: [connection X21/g =>[signal: a_110_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_21 clknet_2_0__leaf_clk clkbuf_2_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: X w=1]]', 'g: [connection X22/g =>[signal: a_110_47# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_22 clknet_2_0__leaf_clk clkbuf_2_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: a_110_47# w=1]]', 's: [connection X23/s =>[signal: X w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_23 VPWR clkbuf_2_0__f_clk_a_110_47# clknet_2_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VPWR w=1]]', 'g: [connection X24/g =>[signal: a_110_47# w=1]]', 's: [connection X24/s =>[signal: X w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_24 VPWR clkbuf_2_0__f_clk_a_110_47# clknet_2_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_110_47# w=1]]', 's: [connection X25/s =>[signal: X w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_25 VGND clkbuf_2_0__f_clk_a_110_47# clknet_2_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: X w=1]]', 'g: [connection X26/g =>[signal: a_110_47# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_26 clknet_2_0__leaf_clk clkbuf_2_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: X w=1]]', 'g: [connection X27/g =>[signal: a_110_47# w=1]]', 's: [connection X27/s =>[signal: VGND w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_27 clknet_2_0__leaf_clk clkbuf_2_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_110_47# w=1]]', 's: [connection X28/s =>[signal: X w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_28 VPWR clkbuf_2_0__f_clk_a_110_47# clknet_2_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: a_110_47# w=1]]', 's: [connection X29/s =>[signal: X w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_29 VGND clkbuf_2_0__f_clk_a_110_47# clknet_2_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: X w=1]]', 'g: [connection X30/g =>[signal: a_110_47# w=1]]', 's: [connection X30/s =>[signal: VGND w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_30 clknet_2_0__leaf_clk clkbuf_2_0__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: X w=1]]', 'g: [connection X31/g =>[signal: a_110_47# w=1]]', 's: [connection X31/s =>[signal: VPWR w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_31 clknet_2_0__leaf_clk clkbuf_2_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X32 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X32/d =>[signal: X w=1]]', 'g: [connection X32/g =>[signal: a_110_47# w=1]]', 's: [connection X32/s =>[signal: VPWR w=1]]', 'b: [connection X32/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_32 clknet_2_0__leaf_clk clkbuf_2_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X33 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X33/d =>[signal: X w=1]]', 'g: [connection X33/g =>[signal: a_110_47# w=1]]', 's: [connection X33/s =>[signal: VPWR w=1]]', 'b: [connection X33/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_33 clknet_2_0__leaf_clk clkbuf_2_0__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X34 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X34/d =>[signal: a_110_47# w=1]]', 'g: [connection X34/g =>[signal: A w=1]]', 's: [connection X34/s =>[signal: VGND w=1]]', 'b: [connection X34/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_34 clkbuf_2_0__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X35 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X35/d =>[signal: VPWR w=1]]', 'g: [connection X35/g =>[signal: a_110_47# w=1]]', 's: [connection X35/s =>[signal: X w=1]]', 'b: [connection X35/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_35 VPWR clkbuf_2_0__f_clk_a_110_47# clknet_2_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X36 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X36/d =>[signal: VGND w=1]]', 'g: [connection X36/g =>[signal: A w=1]]', 's: [connection X36/s =>[signal: a_110_47# w=1]]', 'b: [connection X36/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_36 VGND clknet_0_clk clkbuf_2_0__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X37 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X37/d =>[signal: VPWR w=1]]', 'g: [connection X37/g =>[signal: a_110_47# w=1]]', 's: [connection X37/s =>[signal: X w=1]]', 'b: [connection X37/b =>[signal: VPB w=1]]']]
X_clkbuf_2_0__f_clk_37 VPWR clkbuf_2_0__f_clk_a_110_47# clknet_2_0__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X38 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X38/d =>[signal: VGND w=1]]', 'g: [connection X38/g =>[signal: a_110_47# w=1]]', 's: [connection X38/s =>[signal: X w=1]]', 'b: [connection X38/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_38 VGND clkbuf_2_0__f_clk_a_110_47# clknet_2_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X39 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X39/d =>[signal: VGND w=1]]', 'g: [connection X39/g =>[signal: a_110_47# w=1]]', 's: [connection X39/s =>[signal: X w=1]]', 'b: [connection X39/b =>[signal: VNB w=1]]']]
X_clkbuf_2_0__f_clk_39 VGND clkbuf_2_0__f_clk_a_110_47# clknet_2_0__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing clkbuf_2_1__f_clk with the contents of sky130_fd_sc_hd__clkbuf_16
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_110_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_0 VPWR clkbuf_2_1__f_clk_a_110_47# clknet_2_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_110_47# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_1 clknet_2_1__leaf_clk clkbuf_2_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_110_47# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_2 clknet_2_1__leaf_clk clkbuf_2_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_110_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_3 clkbuf_2_1__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_110_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_4 VPWR clkbuf_2_1__f_clk_a_110_47# clknet_2_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: X w=1]]', 'g: [connection X5/g =>[signal: a_110_47# w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_5 clknet_2_1__leaf_clk clkbuf_2_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_110_47# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_6 clkbuf_2_1__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: a_110_47# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_7 VPWR clknet_0_clk clkbuf_2_1__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: a_110_47# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_8 VGND clkbuf_2_1__f_clk_a_110_47# clknet_2_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_110_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_9 VGND clknet_0_clk clkbuf_2_1__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_110_47# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_10 clknet_2_1__leaf_clk clkbuf_2_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: X w=1]]', 'g: [connection X11/g =>[signal: a_110_47# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_11 clknet_2_1__leaf_clk clkbuf_2_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_110_47# w=1]]', 'g: [connection X12/g =>[signal: A w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_12 clkbuf_2_1__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VPWR w=1]]', 'g: [connection X13/g =>[signal: a_110_47# w=1]]', 's: [connection X13/s =>[signal: X w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_13 VPWR clkbuf_2_1__f_clk_a_110_47# clknet_2_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: X w=1]]', 'g: [connection X14/g =>[signal: a_110_47# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_14 clknet_2_1__leaf_clk clkbuf_2_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: A w=1]]', 's: [connection X15/s =>[signal: a_110_47# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_15 VPWR clknet_0_clk clkbuf_2_1__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_110_47# w=1]]', 's: [connection X16/s =>[signal: X w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_16 VGND clkbuf_2_1__f_clk_a_110_47# clknet_2_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: X w=1]]', 'g: [connection X17/g =>[signal: a_110_47# w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_17 clknet_2_1__leaf_clk clkbuf_2_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_110_47# w=1]]', 's: [connection X18/s =>[signal: X w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_18 VGND clkbuf_2_1__f_clk_a_110_47# clknet_2_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_110_47# w=1]]', 's: [connection X19/s =>[signal: X w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_19 VGND clkbuf_2_1__f_clk_a_110_47# clknet_2_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: X w=1]]', 'g: [connection X20/g =>[signal: a_110_47# w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_20 clknet_2_1__leaf_clk clkbuf_2_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: X w=1]]', 'g: [connection X21/g =>[signal: a_110_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_21 clknet_2_1__leaf_clk clkbuf_2_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: X w=1]]', 'g: [connection X22/g =>[signal: a_110_47# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_22 clknet_2_1__leaf_clk clkbuf_2_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: a_110_47# w=1]]', 's: [connection X23/s =>[signal: X w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_23 VPWR clkbuf_2_1__f_clk_a_110_47# clknet_2_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VPWR w=1]]', 'g: [connection X24/g =>[signal: a_110_47# w=1]]', 's: [connection X24/s =>[signal: X w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_24 VPWR clkbuf_2_1__f_clk_a_110_47# clknet_2_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_110_47# w=1]]', 's: [connection X25/s =>[signal: X w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_25 VGND clkbuf_2_1__f_clk_a_110_47# clknet_2_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: X w=1]]', 'g: [connection X26/g =>[signal: a_110_47# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_26 clknet_2_1__leaf_clk clkbuf_2_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: X w=1]]', 'g: [connection X27/g =>[signal: a_110_47# w=1]]', 's: [connection X27/s =>[signal: VGND w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_27 clknet_2_1__leaf_clk clkbuf_2_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_110_47# w=1]]', 's: [connection X28/s =>[signal: X w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_28 VPWR clkbuf_2_1__f_clk_a_110_47# clknet_2_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: a_110_47# w=1]]', 's: [connection X29/s =>[signal: X w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_29 VGND clkbuf_2_1__f_clk_a_110_47# clknet_2_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: X w=1]]', 'g: [connection X30/g =>[signal: a_110_47# w=1]]', 's: [connection X30/s =>[signal: VGND w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_30 clknet_2_1__leaf_clk clkbuf_2_1__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: X w=1]]', 'g: [connection X31/g =>[signal: a_110_47# w=1]]', 's: [connection X31/s =>[signal: VPWR w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_31 clknet_2_1__leaf_clk clkbuf_2_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X32 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X32/d =>[signal: X w=1]]', 'g: [connection X32/g =>[signal: a_110_47# w=1]]', 's: [connection X32/s =>[signal: VPWR w=1]]', 'b: [connection X32/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_32 clknet_2_1__leaf_clk clkbuf_2_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X33 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X33/d =>[signal: X w=1]]', 'g: [connection X33/g =>[signal: a_110_47# w=1]]', 's: [connection X33/s =>[signal: VPWR w=1]]', 'b: [connection X33/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_33 clknet_2_1__leaf_clk clkbuf_2_1__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X34 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X34/d =>[signal: a_110_47# w=1]]', 'g: [connection X34/g =>[signal: A w=1]]', 's: [connection X34/s =>[signal: VGND w=1]]', 'b: [connection X34/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_34 clkbuf_2_1__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X35 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X35/d =>[signal: VPWR w=1]]', 'g: [connection X35/g =>[signal: a_110_47# w=1]]', 's: [connection X35/s =>[signal: X w=1]]', 'b: [connection X35/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_35 VPWR clkbuf_2_1__f_clk_a_110_47# clknet_2_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X36 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X36/d =>[signal: VGND w=1]]', 'g: [connection X36/g =>[signal: A w=1]]', 's: [connection X36/s =>[signal: a_110_47# w=1]]', 'b: [connection X36/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_36 VGND clknet_0_clk clkbuf_2_1__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X37 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X37/d =>[signal: VPWR w=1]]', 'g: [connection X37/g =>[signal: a_110_47# w=1]]', 's: [connection X37/s =>[signal: X w=1]]', 'b: [connection X37/b =>[signal: VPB w=1]]']]
X_clkbuf_2_1__f_clk_37 VPWR clkbuf_2_1__f_clk_a_110_47# clknet_2_1__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X38 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X38/d =>[signal: VGND w=1]]', 'g: [connection X38/g =>[signal: a_110_47# w=1]]', 's: [connection X38/s =>[signal: X w=1]]', 'b: [connection X38/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_38 VGND clkbuf_2_1__f_clk_a_110_47# clknet_2_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X39 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X39/d =>[signal: VGND w=1]]', 'g: [connection X39/g =>[signal: a_110_47# w=1]]', 's: [connection X39/s =>[signal: X w=1]]', 'b: [connection X39/b =>[signal: VNB w=1]]']]
X_clkbuf_2_1__f_clk_39 VGND clkbuf_2_1__f_clk_a_110_47# clknet_2_1__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing clkbuf_2_2__f_clk with the contents of sky130_fd_sc_hd__clkbuf_16
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_110_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_0 VPWR clkbuf_2_2__f_clk_a_110_47# clknet_2_2__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_110_47# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_1 clknet_2_2__leaf_clk clkbuf_2_2__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_110_47# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_2 clknet_2_2__leaf_clk clkbuf_2_2__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_110_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_3 clkbuf_2_2__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_110_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_4 VPWR clkbuf_2_2__f_clk_a_110_47# clknet_2_2__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: X w=1]]', 'g: [connection X5/g =>[signal: a_110_47# w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_5 clknet_2_2__leaf_clk clkbuf_2_2__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_110_47# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_6 clkbuf_2_2__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: a_110_47# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_7 VPWR clknet_0_clk clkbuf_2_2__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: a_110_47# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_8 VGND clkbuf_2_2__f_clk_a_110_47# clknet_2_2__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_110_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_9 VGND clknet_0_clk clkbuf_2_2__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_110_47# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_10 clknet_2_2__leaf_clk clkbuf_2_2__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: X w=1]]', 'g: [connection X11/g =>[signal: a_110_47# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_11 clknet_2_2__leaf_clk clkbuf_2_2__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_110_47# w=1]]', 'g: [connection X12/g =>[signal: A w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_12 clkbuf_2_2__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VPWR w=1]]', 'g: [connection X13/g =>[signal: a_110_47# w=1]]', 's: [connection X13/s =>[signal: X w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_13 VPWR clkbuf_2_2__f_clk_a_110_47# clknet_2_2__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: X w=1]]', 'g: [connection X14/g =>[signal: a_110_47# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_14 clknet_2_2__leaf_clk clkbuf_2_2__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: A w=1]]', 's: [connection X15/s =>[signal: a_110_47# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_15 VPWR clknet_0_clk clkbuf_2_2__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_110_47# w=1]]', 's: [connection X16/s =>[signal: X w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_16 VGND clkbuf_2_2__f_clk_a_110_47# clknet_2_2__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: X w=1]]', 'g: [connection X17/g =>[signal: a_110_47# w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_17 clknet_2_2__leaf_clk clkbuf_2_2__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_110_47# w=1]]', 's: [connection X18/s =>[signal: X w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_18 VGND clkbuf_2_2__f_clk_a_110_47# clknet_2_2__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_110_47# w=1]]', 's: [connection X19/s =>[signal: X w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_19 VGND clkbuf_2_2__f_clk_a_110_47# clknet_2_2__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: X w=1]]', 'g: [connection X20/g =>[signal: a_110_47# w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_20 clknet_2_2__leaf_clk clkbuf_2_2__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: X w=1]]', 'g: [connection X21/g =>[signal: a_110_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_21 clknet_2_2__leaf_clk clkbuf_2_2__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: X w=1]]', 'g: [connection X22/g =>[signal: a_110_47# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_22 clknet_2_2__leaf_clk clkbuf_2_2__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: a_110_47# w=1]]', 's: [connection X23/s =>[signal: X w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_23 VPWR clkbuf_2_2__f_clk_a_110_47# clknet_2_2__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VPWR w=1]]', 'g: [connection X24/g =>[signal: a_110_47# w=1]]', 's: [connection X24/s =>[signal: X w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_24 VPWR clkbuf_2_2__f_clk_a_110_47# clknet_2_2__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_110_47# w=1]]', 's: [connection X25/s =>[signal: X w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_25 VGND clkbuf_2_2__f_clk_a_110_47# clknet_2_2__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: X w=1]]', 'g: [connection X26/g =>[signal: a_110_47# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_26 clknet_2_2__leaf_clk clkbuf_2_2__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: X w=1]]', 'g: [connection X27/g =>[signal: a_110_47# w=1]]', 's: [connection X27/s =>[signal: VGND w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_27 clknet_2_2__leaf_clk clkbuf_2_2__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_110_47# w=1]]', 's: [connection X28/s =>[signal: X w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_28 VPWR clkbuf_2_2__f_clk_a_110_47# clknet_2_2__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: a_110_47# w=1]]', 's: [connection X29/s =>[signal: X w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_29 VGND clkbuf_2_2__f_clk_a_110_47# clknet_2_2__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: X w=1]]', 'g: [connection X30/g =>[signal: a_110_47# w=1]]', 's: [connection X30/s =>[signal: VGND w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_30 clknet_2_2__leaf_clk clkbuf_2_2__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: X w=1]]', 'g: [connection X31/g =>[signal: a_110_47# w=1]]', 's: [connection X31/s =>[signal: VPWR w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_31 clknet_2_2__leaf_clk clkbuf_2_2__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X32 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X32/d =>[signal: X w=1]]', 'g: [connection X32/g =>[signal: a_110_47# w=1]]', 's: [connection X32/s =>[signal: VPWR w=1]]', 'b: [connection X32/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_32 clknet_2_2__leaf_clk clkbuf_2_2__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X33 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X33/d =>[signal: X w=1]]', 'g: [connection X33/g =>[signal: a_110_47# w=1]]', 's: [connection X33/s =>[signal: VPWR w=1]]', 'b: [connection X33/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_33 clknet_2_2__leaf_clk clkbuf_2_2__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X34 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X34/d =>[signal: a_110_47# w=1]]', 'g: [connection X34/g =>[signal: A w=1]]', 's: [connection X34/s =>[signal: VGND w=1]]', 'b: [connection X34/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_34 clkbuf_2_2__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X35 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X35/d =>[signal: VPWR w=1]]', 'g: [connection X35/g =>[signal: a_110_47# w=1]]', 's: [connection X35/s =>[signal: X w=1]]', 'b: [connection X35/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_35 VPWR clkbuf_2_2__f_clk_a_110_47# clknet_2_2__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X36 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X36/d =>[signal: VGND w=1]]', 'g: [connection X36/g =>[signal: A w=1]]', 's: [connection X36/s =>[signal: a_110_47# w=1]]', 'b: [connection X36/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_36 VGND clknet_0_clk clkbuf_2_2__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X37 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X37/d =>[signal: VPWR w=1]]', 'g: [connection X37/g =>[signal: a_110_47# w=1]]', 's: [connection X37/s =>[signal: X w=1]]', 'b: [connection X37/b =>[signal: VPB w=1]]']]
X_clkbuf_2_2__f_clk_37 VPWR clkbuf_2_2__f_clk_a_110_47# clknet_2_2__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X38 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X38/d =>[signal: VGND w=1]]', 'g: [connection X38/g =>[signal: a_110_47# w=1]]', 's: [connection X38/s =>[signal: X w=1]]', 'b: [connection X38/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_38 VGND clkbuf_2_2__f_clk_a_110_47# clknet_2_2__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X39 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X39/d =>[signal: VGND w=1]]', 'g: [connection X39/g =>[signal: a_110_47# w=1]]', 's: [connection X39/s =>[signal: X w=1]]', 'b: [connection X39/b =>[signal: VNB w=1]]']]
X_clkbuf_2_2__f_clk_39 VGND clkbuf_2_2__f_clk_a_110_47# clknet_2_2__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing clkbuf_2_3__f_clk with the contents of sky130_fd_sc_hd__clkbuf_16
** [instance X0 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VPWR w=1]]', 'g: [connection X0/g =>[signal: a_110_47# w=1]]', 's: [connection X0/s =>[signal: X w=1]]', 'b: [connection X0/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_0 VPWR clkbuf_2_3__f_clk_a_110_47# clknet_2_3__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X1 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_110_47# w=1]]', 's: [connection X1/s =>[signal: VGND w=1]]', 'b: [connection X1/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_1 clknet_2_3__leaf_clk clkbuf_2_3__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_110_47# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_2 clknet_2_3__leaf_clk clkbuf_2_3__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: a_110_47# w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_3 clkbuf_2_3__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_110_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_4 VPWR clkbuf_2_3__f_clk_a_110_47# clknet_2_3__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: X w=1]]', 'g: [connection X5/g =>[signal: a_110_47# w=1]]', 's: [connection X5/s =>[signal: VPWR w=1]]', 'b: [connection X5/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_5 clknet_2_3__leaf_clk clkbuf_2_3__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X6 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X6/d =>[signal: a_110_47# w=1]]', 'g: [connection X6/g =>[signal: A w=1]]', 's: [connection X6/s =>[signal: VGND w=1]]', 'b: [connection X6/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_6 clkbuf_2_3__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X7 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X7/d =>[signal: VPWR w=1]]', 'g: [connection X7/g =>[signal: A w=1]]', 's: [connection X7/s =>[signal: a_110_47# w=1]]', 'b: [connection X7/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_7 VPWR clknet_0_clk clkbuf_2_3__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X8 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X8/d =>[signal: VGND w=1]]', 'g: [connection X8/g =>[signal: a_110_47# w=1]]', 's: [connection X8/s =>[signal: X w=1]]', 'b: [connection X8/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_8 VGND clkbuf_2_3__f_clk_a_110_47# clknet_2_3__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X9 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X9/d =>[signal: VGND w=1]]', 'g: [connection X9/g =>[signal: A w=1]]', 's: [connection X9/s =>[signal: a_110_47# w=1]]', 'b: [connection X9/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_9 VGND clknet_0_clk clkbuf_2_3__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X10 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X10/d =>[signal: X w=1]]', 'g: [connection X10/g =>[signal: a_110_47# w=1]]', 's: [connection X10/s =>[signal: VGND w=1]]', 'b: [connection X10/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_10 clknet_2_3__leaf_clk clkbuf_2_3__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X11 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X11/d =>[signal: X w=1]]', 'g: [connection X11/g =>[signal: a_110_47# w=1]]', 's: [connection X11/s =>[signal: VGND w=1]]', 'b: [connection X11/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_11 clknet_2_3__leaf_clk clkbuf_2_3__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X12 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X12/d =>[signal: a_110_47# w=1]]', 'g: [connection X12/g =>[signal: A w=1]]', 's: [connection X12/s =>[signal: VPWR w=1]]', 'b: [connection X12/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_12 clkbuf_2_3__f_clk_a_110_47# clknet_0_clk VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X13 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X13/d =>[signal: VPWR w=1]]', 'g: [connection X13/g =>[signal: a_110_47# w=1]]', 's: [connection X13/s =>[signal: X w=1]]', 'b: [connection X13/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_13 VPWR clkbuf_2_3__f_clk_a_110_47# clknet_2_3__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X14 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X14/d =>[signal: X w=1]]', 'g: [connection X14/g =>[signal: a_110_47# w=1]]', 's: [connection X14/s =>[signal: VGND w=1]]', 'b: [connection X14/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_14 clknet_2_3__leaf_clk clkbuf_2_3__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X15 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X15/d =>[signal: VPWR w=1]]', 'g: [connection X15/g =>[signal: A w=1]]', 's: [connection X15/s =>[signal: a_110_47# w=1]]', 'b: [connection X15/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_15 VPWR clknet_0_clk clkbuf_2_3__f_clk_a_110_47# VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X16 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X16/d =>[signal: VGND w=1]]', 'g: [connection X16/g =>[signal: a_110_47# w=1]]', 's: [connection X16/s =>[signal: X w=1]]', 'b: [connection X16/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_16 VGND clkbuf_2_3__f_clk_a_110_47# clknet_2_3__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X17 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X17/d =>[signal: X w=1]]', 'g: [connection X17/g =>[signal: a_110_47# w=1]]', 's: [connection X17/s =>[signal: VGND w=1]]', 'b: [connection X17/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_17 clknet_2_3__leaf_clk clkbuf_2_3__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X18 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X18/d =>[signal: VGND w=1]]', 'g: [connection X18/g =>[signal: a_110_47# w=1]]', 's: [connection X18/s =>[signal: X w=1]]', 'b: [connection X18/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_18 VGND clkbuf_2_3__f_clk_a_110_47# clknet_2_3__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X19 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X19/d =>[signal: VGND w=1]]', 'g: [connection X19/g =>[signal: a_110_47# w=1]]', 's: [connection X19/s =>[signal: X w=1]]', 'b: [connection X19/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_19 VGND clkbuf_2_3__f_clk_a_110_47# clknet_2_3__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X20 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X20/d =>[signal: X w=1]]', 'g: [connection X20/g =>[signal: a_110_47# w=1]]', 's: [connection X20/s =>[signal: VPWR w=1]]', 'b: [connection X20/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_20 clknet_2_3__leaf_clk clkbuf_2_3__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X21 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X21/d =>[signal: X w=1]]', 'g: [connection X21/g =>[signal: a_110_47# w=1]]', 's: [connection X21/s =>[signal: VPWR w=1]]', 'b: [connection X21/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_21 clknet_2_3__leaf_clk clkbuf_2_3__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X22 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X22/d =>[signal: X w=1]]', 'g: [connection X22/g =>[signal: a_110_47# w=1]]', 's: [connection X22/s =>[signal: VPWR w=1]]', 'b: [connection X22/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_22 clknet_2_3__leaf_clk clkbuf_2_3__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X23 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X23/d =>[signal: VPWR w=1]]', 'g: [connection X23/g =>[signal: a_110_47# w=1]]', 's: [connection X23/s =>[signal: X w=1]]', 'b: [connection X23/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_23 VPWR clkbuf_2_3__f_clk_a_110_47# clknet_2_3__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X24 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X24/d =>[signal: VPWR w=1]]', 'g: [connection X24/g =>[signal: a_110_47# w=1]]', 's: [connection X24/s =>[signal: X w=1]]', 'b: [connection X24/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_24 VPWR clkbuf_2_3__f_clk_a_110_47# clknet_2_3__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X25 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X25/d =>[signal: VGND w=1]]', 'g: [connection X25/g =>[signal: a_110_47# w=1]]', 's: [connection X25/s =>[signal: X w=1]]', 'b: [connection X25/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_25 VGND clkbuf_2_3__f_clk_a_110_47# clknet_2_3__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X26 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X26/d =>[signal: X w=1]]', 'g: [connection X26/g =>[signal: a_110_47# w=1]]', 's: [connection X26/s =>[signal: VPWR w=1]]', 'b: [connection X26/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_26 clknet_2_3__leaf_clk clkbuf_2_3__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X27 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X27/d =>[signal: X w=1]]', 'g: [connection X27/g =>[signal: a_110_47# w=1]]', 's: [connection X27/s =>[signal: VGND w=1]]', 'b: [connection X27/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_27 clknet_2_3__leaf_clk clkbuf_2_3__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X28 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X28/d =>[signal: VPWR w=1]]', 'g: [connection X28/g =>[signal: a_110_47# w=1]]', 's: [connection X28/s =>[signal: X w=1]]', 'b: [connection X28/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_28 VPWR clkbuf_2_3__f_clk_a_110_47# clknet_2_3__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X29 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X29/d =>[signal: VGND w=1]]', 'g: [connection X29/g =>[signal: a_110_47# w=1]]', 's: [connection X29/s =>[signal: X w=1]]', 'b: [connection X29/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_29 VGND clkbuf_2_3__f_clk_a_110_47# clknet_2_3__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X30 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X30/d =>[signal: X w=1]]', 'g: [connection X30/g =>[signal: a_110_47# w=1]]', 's: [connection X30/s =>[signal: VGND w=1]]', 'b: [connection X30/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_30 clknet_2_3__leaf_clk clkbuf_2_3__f_clk_a_110_47# VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X31 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X31/d =>[signal: X w=1]]', 'g: [connection X31/g =>[signal: a_110_47# w=1]]', 's: [connection X31/s =>[signal: VPWR w=1]]', 'b: [connection X31/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_31 clknet_2_3__leaf_clk clkbuf_2_3__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X32 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X32/d =>[signal: X w=1]]', 'g: [connection X32/g =>[signal: a_110_47# w=1]]', 's: [connection X32/s =>[signal: VPWR w=1]]', 'b: [connection X32/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_32 clknet_2_3__leaf_clk clkbuf_2_3__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X33 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X33/d =>[signal: X w=1]]', 'g: [connection X33/g =>[signal: a_110_47# w=1]]', 's: [connection X33/s =>[signal: VPWR w=1]]', 'b: [connection X33/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_33 clknet_2_3__leaf_clk clkbuf_2_3__f_clk_a_110_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X34 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X34/d =>[signal: a_110_47# w=1]]', 'g: [connection X34/g =>[signal: A w=1]]', 's: [connection X34/s =>[signal: VGND w=1]]', 'b: [connection X34/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_34 clkbuf_2_3__f_clk_a_110_47# clknet_0_clk VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X35 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X35/d =>[signal: VPWR w=1]]', 'g: [connection X35/g =>[signal: a_110_47# w=1]]', 's: [connection X35/s =>[signal: X w=1]]', 'b: [connection X35/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_35 VPWR clkbuf_2_3__f_clk_a_110_47# clknet_2_3__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X36 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X36/d =>[signal: VGND w=1]]', 'g: [connection X36/g =>[signal: A w=1]]', 's: [connection X36/s =>[signal: a_110_47# w=1]]', 'b: [connection X36/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_36 VGND clknet_0_clk clkbuf_2_3__f_clk_a_110_47# VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X37 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X37/d =>[signal: VPWR w=1]]', 'g: [connection X37/g =>[signal: a_110_47# w=1]]', 's: [connection X37/s =>[signal: X w=1]]', 'b: [connection X37/b =>[signal: VPB w=1]]']]
X_clkbuf_2_3__f_clk_37 VPWR clkbuf_2_3__f_clk_a_110_47# clknet_2_3__leaf_clk VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X38 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X38/d =>[signal: VGND w=1]]', 'g: [connection X38/g =>[signal: a_110_47# w=1]]', 's: [connection X38/s =>[signal: X w=1]]', 'b: [connection X38/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_38 VGND clkbuf_2_3__f_clk_a_110_47# clknet_2_3__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u
** [instance X39 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X39/d =>[signal: VGND w=1]]', 'g: [connection X39/g =>[signal: a_110_47# w=1]]', 's: [connection X39/s =>[signal: X w=1]]', 'b: [connection X39/b =>[signal: VNB w=1]]']]
X_clkbuf_2_3__f_clk_39 VGND clkbuf_2_3__f_clk_a_110_47# clknet_2_3__leaf_clk VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

** replacing input1 with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input1_0 VGND decrease_duty input1_a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input1_1 net1 input1_a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input1_2 net1 input1_a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input1_3 VPWR decrease_duty input1_a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing input2 with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input2_0 VGND increase_duty input2_a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input2_1 net2 input2_a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input2_2 net2 input2_a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input2_3 VPWR increase_duty input2_a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing input3 with the contents of sky130_fd_sc_hd__clkbuf_1
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: VGND w=1]]', 'g: [connection X0/g =>[signal: A w=1]]', 's: [connection X0/s =>[signal: a_75_212# w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_input3_0 VGND reset input3_a_75_212# VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: X w=1]]', 'g: [connection X1/g =>[signal: a_75_212# w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_input3_1 net3 input3_a_75_212# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '520000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: X w=1]]', 'g: [connection X2/g =>[signal: a_75_212# w=1]]', 's: [connection X2/s =>[signal: VGND w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_input3_2 net3 input3_a_75_212# VGND VGND sky130_fd_pr__nfet_01v8 W=520000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '790000u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: VPWR w=1]]', 'g: [connection X3/g =>[signal: A w=1]]', 's: [connection X3/s =>[signal: a_75_212# w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_input3_3 VPWR reset input3_a_75_212# VPWR sky130_fd_pr__pfet_01v8_hvt W=790000u L=150000u

** replacing output4 with the contents of sky130_fd_sc_hd__buf_2
** [instance X0 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X0/d =>[signal: X w=1]]', 'g: [connection X0/g =>[signal: a_27_47# w=1]]', 's: [connection X0/s =>[signal: VGND w=1]]', 'b: [connection X0/b =>[signal: VNB w=1]]']]
X_output4_0 PWM_OUT output4_a_27_47# VGND VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X1 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '640000u', 'L': '150000u'} connections=['d: [connection X1/d =>[signal: a_27_47# w=1]]', 'g: [connection X1/g =>[signal: A w=1]]', 's: [connection X1/s =>[signal: VPWR w=1]]', 'b: [connection X1/b =>[signal: VPB w=1]]']]
X_output4_1 output4_a_27_47# net4 VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=640000u L=150000u
** [instance X2 of sky130_fd_pr__nfet_01v8, params={'W': '650000u', 'L': '150000u'} connections=['d: [connection X2/d =>[signal: VGND w=1]]', 'g: [connection X2/g =>[signal: a_27_47# w=1]]', 's: [connection X2/s =>[signal: X w=1]]', 'b: [connection X2/b =>[signal: VNB w=1]]']]
X_output4_2 VGND output4_a_27_47# PWM_OUT VGND sky130_fd_pr__nfet_01v8 W=650000u L=150000u
** [instance X3 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X3/d =>[signal: X w=1]]', 'g: [connection X3/g =>[signal: a_27_47# w=1]]', 's: [connection X3/s =>[signal: VPWR w=1]]', 'b: [connection X3/b =>[signal: VPB w=1]]']]
X_output4_3 PWM_OUT output4_a_27_47# VPWR VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X4 of sky130_fd_pr__pfet_01v8_hvt, params={'W': '1e+06u', 'L': '150000u'} connections=['d: [connection X4/d =>[signal: VPWR w=1]]', 'g: [connection X4/g =>[signal: a_27_47# w=1]]', 's: [connection X4/s =>[signal: X w=1]]', 'b: [connection X4/b =>[signal: VPB w=1]]']]
X_output4_4 VPWR output4_a_27_47# PWM_OUT VPWR sky130_fd_pr__pfet_01v8_hvt W=1e+06u L=150000u
** [instance X5 of sky130_fd_pr__nfet_01v8, params={'W': '420000u', 'L': '150000u'} connections=['d: [connection X5/d =>[signal: a_27_47# w=1]]', 'g: [connection X5/g =>[signal: A w=1]]', 's: [connection X5/s =>[signal: VGND w=1]]', 'b: [connection X5/b =>[signal: VNB w=1]]']]
X_output4_5 output4_a_27_47# net4 VGND VGND sky130_fd_pr__nfet_01v8 W=420000u L=150000u

.ENDS
